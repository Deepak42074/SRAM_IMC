v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 19590 -15430 19590 -15400 {
lab=VDD}
N 19540 -15090 19540 -15060 {
lab=VSS}
N 19480 -15440 19480 -15400 {
lab=WWL[0:15]}
N 19680 -15330 19710 -15330 {
lab=BLB[0]}
N 19710 -15330 19750 -15330 {
lab=BLB[0]}
N 19370 -15330 19420 -15330 {
lab=BL[0]}
N 19370 -15280 19420 -15280 {
lab=RWL[0:15]}
N 19680 -15280 19750 -15280 {
lab=RWLB[0:15]}
N 19380 -15170 19420 -15170 {
lab=RBLX[0]}
N 19680 -15170 19760 -15170 {
lab=RBLX[0]}
N 19380 -15170 19380 -14980 {
lab=RBLX[0]}
N 19760 -15170 19760 -14980 {
lab=RBLX[0]}
N 20260 -15430 20260 -15400 {
lab=VDD}
N 20210 -15090 20210 -15060 {
lab=VSS}
N 20150 -15440 20150 -15400 {
lab=WWL[0:15]}
N 20350 -15330 20380 -15330 {
lab=BLB[1]}
N 20380 -15330 20420 -15330 {
lab=BLB[1]}
N 20040 -15330 20090 -15330 {
lab=BL[1]}
N 20040 -15280 20090 -15280 {
lab=RWL[0:15]}
N 20350 -15280 20420 -15280 {
lab=RWLB[0:15]}
N 20050 -15170 20090 -15170 {
lab=RBLX[1]}
N 20350 -15170 20430 -15170 {
lab=RBLX[1]}
N 20050 -15170 20050 -14980 {
lab=RBLX[1]}
N 20430 -15170 20430 -14980 {
lab=RBLX[1]}
N 20930 -15430 20930 -15400 {
lab=VDD}
N 20880 -15090 20880 -15060 {
lab=VSS}
N 20820 -15440 20820 -15400 {
lab=WWL[0:15]}
N 21020 -15330 21050 -15330 {
lab=BLB[2]}
N 21050 -15330 21090 -15330 {
lab=BLB[2]}
N 20710 -15330 20760 -15330 {
lab=BL[2]}
N 20710 -15280 20760 -15280 {
lab=RWL[0:15]}
N 21020 -15280 21090 -15280 {
lab=RWLB[0:15]}
N 20720 -15170 20760 -15170 {
lab=RBLX[2]}
N 21020 -15170 21100 -15170 {
lab=RBLX[2]}
N 20720 -15170 20720 -14980 {
lab=RBLX[2]}
N 21100 -15170 21100 -14980 {
lab=RBLX[2]}
N 21600 -15430 21600 -15400 {
lab=VDD}
N 21550 -15090 21550 -15060 {
lab=VSS}
N 21490 -15440 21490 -15400 {
lab=WWL[0:15]}
N 21690 -15330 21720 -15330 {
lab=BLB[3]}
N 21720 -15330 21760 -15330 {
lab=BLB[3]}
N 21380 -15330 21430 -15330 {
lab=BL[3]}
N 21380 -15280 21430 -15280 {
lab=RWL[0:15]}
N 21690 -15280 21760 -15280 {
lab=RWLB[0:15]}
N 21390 -15170 21430 -15170 {
lab=RBLX[3]}
N 21690 -15170 21770 -15170 {
lab=RBLX[3]}
N 21390 -15170 21390 -14980 {
lab=RBLX[3]}
N 21770 -15170 21770 -14980 {
lab=RBLX[3]}
N 22280 -15440 22280 -15410 {
lab=VDD}
N 22230 -15100 22230 -15070 {
lab=VSS}
N 22170 -15450 22170 -15410 {
lab=WWL[0:15]}
N 22370 -15340 22400 -15340 {
lab=BLB[4]}
N 22400 -15340 22440 -15340 {
lab=BLB[4]}
N 22060 -15340 22110 -15340 {
lab=BL[4]}
N 22060 -15290 22110 -15290 {
lab=RWL[0:15]}
N 22370 -15290 22440 -15290 {
lab=RWLB[0:15]}
N 22070 -15180 22110 -15180 {
lab=RBLX[4]}
N 22370 -15180 22450 -15180 {
lab=RBLX[4]}
N 22070 -15180 22070 -14990 {
lab=RBLX[4]}
N 22450 -15180 22450 -14990 {
lab=RBLX[4]}
N 22950 -15440 22950 -15410 {
lab=VDD}
N 22900 -15100 22900 -15070 {
lab=VSS}
N 22840 -15450 22840 -15410 {
lab=WWL[0:15]}
N 23040 -15340 23070 -15340 {
lab=BLB[5]}
N 23070 -15340 23110 -15340 {
lab=BLB[5]}
N 22730 -15340 22780 -15340 {
lab=BL[5]}
N 22730 -15290 22780 -15290 {
lab=RWL[0:15]}
N 23040 -15290 23110 -15290 {
lab=RWLB[0:15]}
N 22740 -15180 22780 -15180 {
lab=RBLX[5]}
N 23040 -15180 23120 -15180 {
lab=RBLX[5]}
N 22740 -15180 22740 -14990 {
lab=RBLX[5]}
N 23120 -15180 23120 -14990 {
lab=RBLX[5]}
N 23620 -15440 23620 -15410 {
lab=VDD}
N 23570 -15100 23570 -15070 {
lab=VSS}
N 23510 -15450 23510 -15410 {
lab=WWL[0:15]}
N 23710 -15340 23740 -15340 {
lab=BLB[6]}
N 23740 -15340 23780 -15340 {
lab=BLB[6]}
N 23400 -15340 23450 -15340 {
lab=BL[6]}
N 23400 -15290 23450 -15290 {
lab=RWL[0:15]}
N 23710 -15290 23780 -15290 {
lab=RWLB[0:15]}
N 23410 -15180 23450 -15180 {
lab=RBLX[6]}
N 23710 -15180 23790 -15180 {
lab=RBLX[6]}
N 23410 -15180 23410 -14990 {
lab=RBLX[6]}
N 23790 -15180 23790 -14990 {
lab=RBLX[6]}
N 24290 -15440 24290 -15410 {
lab=VDD}
N 24240 -15100 24240 -15070 {
lab=VSS}
N 24180 -15450 24180 -15410 {
lab=WWL[0:15]}
N 24380 -15340 24410 -15340 {
lab=BLB[7]}
N 24410 -15340 24450 -15340 {
lab=BLB[7]}
N 24070 -15340 24120 -15340 {
lab=BL[7]}
N 24070 -15290 24120 -15290 {
lab=RWL[0:15]}
N 24380 -15290 24450 -15290 {
lab=RWLB[0:15]}
N 24080 -15180 24120 -15180 {
lab=RBLX[7]}
N 24380 -15180 24460 -15180 {
lab=RBLX[7]}
N 24080 -15180 24080 -14990 {
lab=RBLX[7]}
N 24460 -15180 24460 -14990 {
lab=RBLX[7]}
N 24910 -15430 24910 -15400 {
lab=VDD}
N 24860 -15090 24860 -15060 {
lab=VSS}
N 24800 -15440 24800 -15400 {
lab=WWL[0:15]}
N 25000 -15330 25030 -15330 {
lab=BLB[8]}
N 25030 -15330 25070 -15330 {
lab=BLB[8]}
N 24690 -15330 24740 -15330 {
lab=BL[8]}
N 24690 -15280 24740 -15280 {
lab=RWL[0:15]}
N 25000 -15280 25070 -15280 {
lab=RWLB[0:15]}
N 24700 -15170 24740 -15170 {
lab=RBLX[8]}
N 25000 -15170 25080 -15170 {
lab=RBLX[8]}
N 24700 -15170 24700 -14980 {
lab=RBLX[8]}
N 25080 -15170 25080 -14980 {
lab=RBLX[8]}
N 25580 -15430 25580 -15400 {
lab=VDD}
N 25530 -15090 25530 -15060 {
lab=VSS}
N 25470 -15440 25470 -15400 {
lab=WWL[0:15]}
N 25670 -15330 25700 -15330 {
lab=BLB[9]}
N 25700 -15330 25740 -15330 {
lab=BLB[9]}
N 25360 -15330 25410 -15330 {
lab=BL[9]}
N 25360 -15280 25410 -15280 {
lab=RWL[0:15]}
N 25670 -15280 25740 -15280 {
lab=RWLB[0:15]}
N 25370 -15170 25410 -15170 {
lab=RBLX[9]}
N 25670 -15170 25750 -15170 {
lab=RBLX[9]}
N 25370 -15170 25370 -14980 {
lab=RBLX[9]}
N 25750 -15170 25750 -14980 {
lab=RBLX[9]}
N 26250 -15430 26250 -15400 {
lab=VDD}
N 26200 -15090 26200 -15060 {
lab=VSS}
N 26140 -15440 26140 -15400 {
lab=WWL[0:15]}
N 26340 -15330 26370 -15330 {
lab=BLB[10]}
N 26370 -15330 26410 -15330 {
lab=BLB[10]}
N 26030 -15330 26080 -15330 {
lab=BL[10]}
N 26030 -15280 26080 -15280 {
lab=RWL[0:15]}
N 26340 -15280 26410 -15280 {
lab=RWLB[0:15]}
N 26040 -15170 26080 -15170 {
lab=RBLX[10]}
N 26340 -15170 26420 -15170 {
lab=RBLX[10]}
N 26040 -15170 26040 -14980 {
lab=RBLX[10]}
N 26420 -15170 26420 -14980 {
lab=RBLX[10]}
N 27030 -15430 27030 -15400 {
lab=VDD}
N 26980 -15090 26980 -15060 {
lab=VSS}
N 26920 -15440 26920 -15400 {
lab=WWL[0:15]}
N 27120 -15330 27150 -15330 {
lab=BLB[11]}
N 27150 -15330 27190 -15330 {
lab=BLB[11]}
N 26810 -15330 26860 -15330 {
lab=BL[11]}
N 26810 -15280 26860 -15280 {
lab=RWL[0:15]}
N 27120 -15280 27190 -15280 {
lab=RWLB[0:15]}
N 26820 -15170 26860 -15170 {
lab=RBLX[11]}
N 27120 -15170 27200 -15170 {
lab=RBLX[11]}
N 26820 -15170 26820 -14980 {
lab=RBLX[11]}
N 27200 -15170 27200 -14980 {
lab=RBLX[11]}
N 27670 -15440 27670 -15410 {
lab=VDD}
N 27620 -15100 27620 -15070 {
lab=VSS}
N 27560 -15450 27560 -15410 {
lab=WWL[0:15]}
N 27760 -15340 27790 -15340 {
lab=BLB[12]}
N 27790 -15340 27830 -15340 {
lab=BLB[12]}
N 27450 -15340 27500 -15340 {
lab=BL[12]}
N 27450 -15290 27500 -15290 {
lab=RWL[0:15]}
N 27760 -15290 27830 -15290 {
lab=RWLB[0:15]}
N 27460 -15180 27500 -15180 {
lab=RBLX[12]}
N 27760 -15180 27840 -15180 {
lab=RBLX[12]}
N 27460 -15180 27460 -14990 {
lab=RBLX[12]}
N 27840 -15180 27840 -14990 {
lab=RBLX[12]}
N 28360 -15440 28360 -15410 {
lab=VDD}
N 28310 -15100 28310 -15070 {
lab=VSS}
N 28250 -15450 28250 -15410 {
lab=WWL[0:15]}
N 28450 -15340 28480 -15340 {
lab=BLB[13]}
N 28480 -15340 28520 -15340 {
lab=BLB[13]}
N 28140 -15340 28190 -15340 {
lab=BL[13]}
N 28140 -15290 28190 -15290 {
lab=RWL[0:15]}
N 28450 -15290 28520 -15290 {
lab=RWLB[0:15]}
N 28150 -15180 28190 -15180 {
lab=RBLX[13]}
N 28450 -15180 28530 -15180 {
lab=RBLX[13]}
N 28150 -15180 28150 -14990 {
lab=RBLX[13]}
N 28530 -15180 28530 -14990 {
lab=RBLX[13]}
N 29080 -15450 29080 -15420 {
lab=VDD}
N 29030 -15110 29030 -15080 {
lab=VSS}
N 28970 -15460 28970 -15420 {
lab=WWL[0:15]}
N 29170 -15350 29200 -15350 {
lab=BLB[14]}
N 29200 -15350 29240 -15350 {
lab=BLB[14]}
N 28860 -15350 28910 -15350 {
lab=BL[14]}
N 28860 -15300 28910 -15300 {
lab=RWL[0:15]}
N 29170 -15300 29240 -15300 {
lab=RWLB[0:15]}
N 28870 -15190 28910 -15190 {
lab=RBLX[14]}
N 29170 -15190 29250 -15190 {
lab=RBLX[14]}
N 28870 -15190 28870 -15000 {
lab=RBLX[14]}
N 29250 -15190 29250 -15000 {
lab=RBLX[14]}
N 29750 -15450 29750 -15420 {
lab=VDD}
N 29700 -15110 29700 -15080 {
lab=VSS}
N 29640 -15460 29640 -15420 {
lab=WWL[0:15]}
N 29840 -15350 29870 -15350 {
lab=BLB[15]}
N 29870 -15350 29910 -15350 {
lab=BLB[15]}
N 29530 -15350 29580 -15350 {
lab=BL[15]}
N 29530 -15300 29580 -15300 {
lab=RWL[0:15]}
N 29840 -15300 29910 -15300 {
lab=RWLB[0:15]}
N 29540 -15190 29580 -15190 {
lab=RBLX[15]}
N 29840 -15190 29920 -15190 {
lab=RBLX[15]}
N 29540 -15190 29540 -15000 {
lab=RBLX[15]}
N 29920 -15190 29920 -15000 {
lab=RBLX[15]}
N 19580 -15700 19580 -15680 {
lab=VDD}
N 19520 -15700 19520 -15680 {
lab=PRE_SRAM}
N 19410 -15630 19460 -15630 {
lab=BL[0]}
N 19620 -15630 19660 -15630 {
lab=BLB[0]}
N 19530 -15980 19530 -15960 {
lab=VDD}
N 19530 -15840 19530 -15810 {
lab=VSS}
N 19410 -15930 19450 -15930 {
lab=WE}
N 19410 -15910 19450 -15910 {
lab=Din[0]}
N 19400 -15880 19450 -15880 {
lab=BL[0]}
N 19620 -15880 19660 -15880 {
lab=BLB[0]}
N 20220 -15700 20220 -15680 {
lab=VDD}
N 20160 -15700 20160 -15680 {
lab=PRE_SRAM}
N 20050 -15630 20100 -15630 {
lab=BL[1]}
N 20260 -15630 20300 -15630 {
lab=BLB[1]}
N 20160 -15980 20160 -15960 {
lab=VDD}
N 20160 -15840 20160 -15810 {
lab=VSS}
N 20040 -15930 20080 -15930 {
lab=WE}
N 20040 -15910 20080 -15910 {
lab=Din[1]}
N 20030 -15880 20080 -15880 {
lab=BL[1]}
N 20250 -15880 20290 -15880 {
lab=BLB[1]}
N 20890 -15700 20890 -15680 {
lab=VDD}
N 20830 -15700 20830 -15680 {
lab=PRE_SRAM}
N 20720 -15630 20770 -15630 {
lab=BL[2]}
N 20930 -15630 20970 -15630 {
lab=BLB[2]}
N 20840 -15980 20840 -15960 {
lab=VDD}
N 20840 -15840 20840 -15810 {
lab=VSS}
N 20720 -15930 20760 -15930 {
lab=WE}
N 20720 -15910 20760 -15910 {
lab=Din[2]}
N 20710 -15880 20760 -15880 {
lab=BL[2]}
N 20930 -15880 20970 -15880 {
lab=BLB[2]}
N 21530 -15700 21530 -15680 {
lab=VDD}
N 21470 -15700 21470 -15680 {
lab=PRE_SRAM}
N 21360 -15630 21410 -15630 {
lab=BL[3]}
N 21570 -15630 21610 -15630 {
lab=BLB[3]}
N 21480 -15980 21480 -15960 {
lab=VDD}
N 21480 -15840 21480 -15810 {
lab=VSS}
N 21360 -15930 21400 -15930 {
lab=WE}
N 21360 -15910 21400 -15910 {
lab=Din[3]}
N 21350 -15880 21400 -15880 {
lab=BL[3]}
N 21570 -15880 21610 -15880 {
lab=BLB[3]}
N 22260 -15700 22260 -15680 {
lab=VDD}
N 22200 -15700 22200 -15680 {
lab=PRE_SRAM}
N 22090 -15630 22140 -15630 {
lab=BL[4]}
N 22300 -15630 22340 -15630 {
lab=BLB[4]}
N 22210 -15980 22210 -15960 {
lab=VDD}
N 22210 -15840 22210 -15810 {
lab=VSS}
N 22090 -15930 22130 -15930 {
lab=WE}
N 22090 -15910 22130 -15910 {
lab=Din[4]}
N 22080 -15880 22130 -15880 {
lab=BL[4]}
N 22300 -15880 22340 -15880 {
lab=BLB[4]}
N 22900 -15700 22900 -15680 {
lab=VDD}
N 22840 -15700 22840 -15680 {
lab=PRE_SRAM}
N 22730 -15630 22780 -15630 {
lab=BL[5]}
N 22940 -15630 22980 -15630 {
lab=BLB[5]}
N 22840 -15970 22840 -15950 {
lab=VDD}
N 22840 -15830 22840 -15800 {
lab=VSS}
N 22720 -15920 22760 -15920 {
lab=WE}
N 22720 -15900 22760 -15900 {
lab=Din[5]}
N 22710 -15870 22760 -15870 {
lab=BL[5]}
N 22930 -15870 22970 -15870 {
lab=BLB[5]}
N 23570 -15700 23570 -15680 {
lab=VDD}
N 23510 -15700 23510 -15680 {
lab=PRE_SRAM}
N 23400 -15630 23450 -15630 {
lab=BL[6]}
N 23610 -15630 23650 -15630 {
lab=BLB[6]}
N 23510 -15960 23510 -15940 {
lab=VDD}
N 23510 -15820 23510 -15790 {
lab=VSS}
N 23390 -15910 23430 -15910 {
lab=WE}
N 23390 -15890 23430 -15890 {
lab=Din[6]}
N 23380 -15860 23430 -15860 {
lab=BL[6]}
N 23600 -15860 23640 -15860 {
lab=BLB[6]}
N 24210 -15700 24210 -15680 {
lab=VDD}
N 24150 -15700 24150 -15680 {
lab=PRE_SRAM}
N 24040 -15630 24090 -15630 {
lab=BL[7]}
N 24250 -15630 24290 -15630 {
lab=BLB[7]}
N 24180 -15940 24180 -15920 {
lab=VDD}
N 24180 -15800 24180 -15770 {
lab=VSS}
N 24060 -15890 24100 -15890 {
lab=WE}
N 24060 -15870 24100 -15870 {
lab=Din[7]}
N 24050 -15840 24100 -15840 {
lab=BL[7]}
N 24270 -15840 24310 -15840 {
lab=BLB[7]}
N 24870 -15680 24870 -15660 {
lab=VDD}
N 24810 -15680 24810 -15660 {
lab=PRE_SRAM}
N 24700 -15610 24750 -15610 {
lab=BL[8]}
N 24910 -15610 24950 -15610 {
lab=BLB[8]}
N 24840 -15940 24840 -15920 {
lab=VDD}
N 24840 -15800 24840 -15770 {
lab=VSS}
N 24720 -15890 24760 -15890 {
lab=WE}
N 24720 -15870 24760 -15870 {
lab=Din[8]}
N 24710 -15840 24760 -15840 {
lab=BL[8]}
N 24930 -15840 24970 -15840 {
lab=BLB[8]}
N 25570 -15680 25570 -15660 {
lab=VDD}
N 25510 -15680 25510 -15660 {
lab=PRE_SRAM}
N 25400 -15610 25450 -15610 {
lab=BL[9]}
N 25610 -15610 25650 -15610 {
lab=BLB[9]}
N 25510 -15940 25510 -15920 {
lab=VDD}
N 25510 -15800 25510 -15770 {
lab=VSS}
N 25390 -15890 25430 -15890 {
lab=WE}
N 25390 -15870 25430 -15870 {
lab=Din[9]}
N 25380 -15840 25430 -15840 {
lab=BL[9]}
N 25600 -15840 25640 -15840 {
lab=BLB[9]}
N 26240 -15660 26240 -15640 {
lab=VDD}
N 26180 -15660 26180 -15640 {
lab=PRE_SRAM}
N 26070 -15590 26120 -15590 {
lab=BL[10]}
N 26280 -15590 26320 -15590 {
lab=BLB[10]}
N 26190 -15940 26190 -15920 {
lab=VDD}
N 26190 -15800 26190 -15770 {
lab=VSS}
N 26070 -15890 26110 -15890 {
lab=WE}
N 26070 -15870 26110 -15870 {
lab=Din[10]}
N 26060 -15840 26110 -15840 {
lab=BL[10]}
N 26280 -15840 26320 -15840 {
lab=BLB[10]}
N 26980 -15660 26980 -15640 {
lab=VDD}
N 26920 -15660 26920 -15640 {
lab=PRE_SRAM}
N 26810 -15590 26860 -15590 {
lab=BL[11]}
N 27020 -15590 27060 -15590 {
lab=BLB[11]}
N 26920 -15940 26920 -15920 {
lab=VDD}
N 26920 -15800 26920 -15770 {
lab=VSS}
N 26800 -15890 26840 -15890 {
lab=WE}
N 26800 -15870 26840 -15870 {
lab=Din[11]}
N 26790 -15840 26840 -15840 {
lab=BL[11]}
N 27010 -15840 27050 -15840 {
lab=BLB[11]}
N 27640 -15670 27640 -15650 {
lab=VDD}
N 27580 -15670 27580 -15650 {
lab=PRE_SRAM}
N 27470 -15600 27520 -15600 {
lab=BL[12]}
N 27680 -15600 27720 -15600 {
lab=BLB[12]}
N 27580 -15950 27580 -15930 {
lab=VDD}
N 27580 -15810 27580 -15780 {
lab=VSS}
N 27460 -15900 27500 -15900 {
lab=WE}
N 27460 -15880 27500 -15880 {
lab=Din[12]}
N 27450 -15850 27500 -15850 {
lab=BL[12]}
N 27670 -15850 27710 -15850 {
lab=BLB[12]}
N 28310 -15670 28310 -15650 {
lab=VDD}
N 28250 -15670 28250 -15650 {
lab=PRE_SRAM}
N 28140 -15600 28190 -15600 {
lab=BL[13]}
N 28350 -15600 28390 -15600 {
lab=BLB[13]}
N 28250 -15950 28250 -15930 {
lab=VDD}
N 28250 -15810 28250 -15780 {
lab=VSS}
N 28130 -15900 28170 -15900 {
lab=WE}
N 28130 -15880 28170 -15880 {
lab=Din[13]}
N 28120 -15850 28170 -15850 {
lab=BL[13]}
N 28340 -15850 28380 -15850 {
lab=BLB[13]}
N 29040 -15670 29040 -15650 {
lab=VDD}
N 28980 -15670 28980 -15650 {
lab=PRE_SRAM}
N 28870 -15600 28920 -15600 {
lab=BL[14]}
N 29080 -15600 29120 -15600 {
lab=BLB[14]}
N 28980 -15950 28980 -15930 {
lab=VDD}
N 28980 -15810 28980 -15780 {
lab=VSS}
N 28860 -15900 28900 -15900 {
lab=WE}
N 28860 -15880 28900 -15880 {
lab=Din[14]}
N 28850 -15850 28900 -15850 {
lab=BL[14]}
N 29070 -15850 29110 -15850 {
lab=BLB[14]}
N 29720 -15670 29720 -15650 {
lab=VDD}
N 29660 -15670 29660 -15650 {
lab=PRE_SRAM}
N 29550 -15600 29600 -15600 {
lab=BL[15]}
N 29760 -15600 29800 -15600 {
lab=BLB[15]}
N 29660 -15960 29660 -15940 {
lab=VDD}
N 29660 -15820 29660 -15790 {
lab=VSS}
N 29540 -15910 29580 -15910 {
lab=WE}
N 29540 -15890 29580 -15890 {
lab=Din[15]}
N 29530 -15860 29580 -15860 {
lab=BL[15]}
N 29750 -15860 29790 -15860 {
lab=BLB[15]}
N 19520 -14780 19520 -14750 {
lab=PRE_VLSA}
N 19570 -14780 19570 -14750 {
lab=BLB[0]}
N 19620 -14780 19620 -14750 {
lab=BL[0]}
N 19440 -14630 19480 -14630 {
lab=VSS}
N 19660 -14630 19700 -14630 {
lab=VDD}
N 19570 -14490 19570 -14460 {
lab=SA_OUT[0]}
N 20190 -14780 20190 -14750 {
lab=PRE_VLSA}
N 20240 -14780 20240 -14750 {
lab=BLB[1]}
N 20290 -14780 20290 -14750 {
lab=BL[1]}
N 20110 -14630 20150 -14630 {
lab=VSS}
N 20330 -14630 20370 -14630 {
lab=VDD}
N 20240 -14490 20240 -14460 {
lab=SA_OUT[1]}
N 20890 -14780 20890 -14750 {
lab=PRE_VLSA}
N 20940 -14780 20940 -14750 {
lab=BLB[2]}
N 20990 -14780 20990 -14750 {
lab=BL[2]}
N 20810 -14630 20850 -14630 {
lab=VSS}
N 21030 -14630 21070 -14630 {
lab=VDD}
N 20940 -14490 20940 -14460 {
lab=SA_OUT[2]}
N 21560 -14780 21560 -14750 {
lab=PRE_VLSA}
N 21610 -14780 21610 -14750 {
lab=BLB[3]}
N 21660 -14780 21660 -14750 {
lab=BL[3]}
N 21480 -14630 21520 -14630 {
lab=VSS}
N 21700 -14630 21740 -14630 {
lab=VDD}
N 22220 -14790 22220 -14760 {
lab=PRE_VLSA}
N 22270 -14790 22270 -14760 {
lab=BLB[4]}
N 22320 -14790 22320 -14760 {
lab=BL[4]}
N 22140 -14640 22180 -14640 {
lab=VSS}
N 22360 -14640 22400 -14640 {
lab=VDD}
N 22270 -14500 22270 -14470 {
lab=SA_OUT[4]}
N 22890 -14790 22890 -14760 {
lab=PRE_VLSA}
N 22940 -14790 22940 -14760 {
lab=BLB[5]}
N 22990 -14790 22990 -14760 {
lab=BL[5]}
N 22810 -14640 22850 -14640 {
lab=VSS}
N 23030 -14640 23070 -14640 {
lab=VDD}
N 22940 -14500 22940 -14470 {
lab=SA_OUT[5]}
N 23590 -14790 23590 -14760 {
lab=PRE_VLSA}
N 23640 -14790 23640 -14760 {
lab=BLB[6]}
N 23690 -14790 23690 -14760 {
lab=BL[6]}
N 23510 -14640 23550 -14640 {
lab=VSS}
N 23730 -14640 23770 -14640 {
lab=VDD}
N 23640 -14500 23640 -14470 {
lab=SA_OUT[6]}
N 24260 -14790 24260 -14760 {
lab=PRE_VLSA}
N 24310 -14790 24310 -14760 {
lab=BLB[7]}
N 24360 -14790 24360 -14760 {
lab=BL[7]}
N 24180 -14640 24220 -14640 {
lab=VSS}
N 24400 -14640 24440 -14640 {
lab=VDD}
N 24310 -14500 24310 -14470 {
lab=SA_OUT[7]}
N 24840 -14780 24840 -14750 {
lab=PRE_VLSA}
N 24890 -14780 24890 -14750 {
lab=BLB[8]}
N 24940 -14780 24940 -14750 {
lab=BL[8]}
N 24760 -14630 24800 -14630 {
lab=VSS}
N 24980 -14630 25020 -14630 {
lab=VDD}
N 24890 -14490 24890 -14460 {
lab=SA_OUT[8]}
N 25510 -14780 25510 -14750 {
lab=PRE_VLSA}
N 25560 -14780 25560 -14750 {
lab=BLB[9]}
N 25610 -14780 25610 -14750 {
lab=BL[9]}
N 25430 -14630 25470 -14630 {
lab=VSS}
N 25650 -14630 25690 -14630 {
lab=VDD}
N 25560 -14490 25560 -14460 {
lab=SA_OUT[9]}
N 26210 -14780 26210 -14750 {
lab=PRE_VLSA}
N 26260 -14780 26260 -14750 {
lab=BLB[10]}
N 26310 -14780 26310 -14750 {
lab=BL[10]}
N 26130 -14630 26170 -14630 {
lab=VSS}
N 26350 -14630 26390 -14630 {
lab=VDD}
N 26260 -14490 26260 -14460 {
lab=SA_OUT[10]}
N 26990 -14760 26990 -14730 {
lab=PRE_VLSA}
N 27040 -14760 27040 -14730 {
lab=BLB[11]}
N 27090 -14760 27090 -14730 {
lab=BL[11]}
N 26910 -14610 26950 -14610 {
lab=VSS}
N 27130 -14610 27170 -14610 {
lab=VDD}
N 27040 -14470 27040 -14440 {
lab=SA_OUT[11]}
N 27610 -14760 27610 -14730 {
lab=PRE_VLSA}
N 27660 -14760 27660 -14730 {
lab=BLB[12]}
N 27710 -14760 27710 -14730 {
lab=BL[12]}
N 27530 -14610 27570 -14610 {
lab=VSS}
N 27750 -14610 27790 -14610 {
lab=VDD}
N 27660 -14470 27660 -14440 {
lab=SA_OUT[12]}
N 28290 -14750 28290 -14720 {
lab=PRE_VLSA}
N 28340 -14750 28340 -14720 {
lab=BLB[13]}
N 28390 -14750 28390 -14720 {
lab=BL[13]}
N 28210 -14600 28250 -14600 {
lab=VSS}
N 28430 -14600 28470 -14600 {
lab=VDD}
N 28340 -14460 28340 -14430 {
lab=SA_OUT[13]}
N 29010 -14750 29010 -14720 {
lab=PRE_VLSA}
N 29060 -14750 29060 -14720 {
lab=BLB[14]}
N 29110 -14750 29110 -14720 {
lab=BL[14]}
N 28930 -14600 28970 -14600 {
lab=VSS}
N 29150 -14600 29190 -14600 {
lab=VDD}
N 29060 -14460 29060 -14430 {
lab=SA_OUT[14]}
N 29670 -14750 29670 -14720 {
lab=PRE_VLSA}
N 29720 -14750 29720 -14720 {
lab=BLB[15]}
N 29770 -14750 29770 -14720 {
lab=BL[15]}
N 29590 -14600 29630 -14600 {
lab=VSS}
N 29810 -14600 29850 -14600 {
lab=VDD}
N 29720 -14460 29720 -14430 {
lab=SA_OUT[15]}
N 19570 -14310 19570 -14260 {
lab=RBLX[0]}
N 19230 -14250 19230 -14200 { lab=VDD}
N 19230 -14170 19240 -14170 { lab=VDD}
N 19240 -14200 19240 -14170 { lab=VDD}
N 19230 -14200 19240 -14200 { lab=VDD}
N 19140 -14170 19190 -14170 { lab=PRE[0]}
N 19230 -14140 19230 -14090 { lab=O0}
N 19550 -14210 19570 -14210 { lab=VSS}
N 19610 -14210 19640 -14210 { lab=EN[0]}
N 19230 -14090 19470 -14090 { lab=O0}
N 19570 -14260 19570 -14240 {
lab=RBLX[0]}
N 19470 -14090 19570 -14090 {
lab=O0}
N 19570 -14180 19570 -14090 {
lab=O0}
N 20270 -14310 20270 -14260 {
lab=RBLX[1]}
N 19930 -14250 19930 -14200 { lab=VDD}
N 19930 -14170 19940 -14170 { lab=VDD}
N 19940 -14200 19940 -14170 { lab=VDD}
N 19930 -14200 19940 -14200 { lab=VDD}
N 19840 -14170 19890 -14170 { lab=PRE[1]}
N 19930 -14140 19930 -14090 { lab=O1}
N 20250 -14210 20270 -14210 { lab=VSS}
N 20310 -14210 20340 -14210 { lab=EN[1]}
N 19930 -14090 20170 -14090 { lab=O1}
N 20270 -14260 20270 -14240 {
lab=RBLX[1]}
N 20170 -14090 20270 -14090 {
lab=O1}
N 20270 -14180 20270 -14090 {
lab=O1}
N 20270 -14090 20270 -13940 {
lab=O1}
N 20940 -14310 20940 -14260 {
lab=RBLX[2]}
N 20600 -14250 20600 -14200 { lab=VDD}
N 20600 -14170 20610 -14170 { lab=VDD}
N 20610 -14200 20610 -14170 { lab=VDD}
N 20600 -14200 20610 -14200 { lab=VDD}
N 20510 -14170 20560 -14170 { lab=PRE[2]}
N 20600 -14140 20600 -14090 { lab=O2}
N 20920 -14210 20940 -14210 { lab=VSS}
N 20980 -14210 21010 -14210 { lab=EN[2]}
N 20600 -14090 20840 -14090 { lab=O2}
N 20940 -14260 20940 -14240 {
lab=RBLX[2]}
N 20840 -14090 20940 -14090 {
lab=O2}
N 20940 -14180 20940 -14090 {
lab=O2}
N 20940 -14090 20940 -13940 {
lab=O2}
N 21640 -14310 21640 -14260 {
lab=RBLX[3]}
N 21300 -14250 21300 -14200 { lab=VDD}
N 21300 -14170 21310 -14170 { lab=VDD}
N 21310 -14200 21310 -14170 { lab=VDD}
N 21300 -14200 21310 -14200 { lab=VDD}
N 21210 -14170 21260 -14170 { lab=PRE[3]}
N 21300 -14140 21300 -14090 { lab=O3}
N 21620 -14210 21640 -14210 { lab=VSS}
N 21680 -14210 21710 -14210 { lab=EN[3]}
N 21300 -14090 21540 -14090 { lab=O3}
N 21640 -14260 21640 -14240 {
lab=RBLX[3]}
N 21540 -14090 21640 -14090 {
lab=O3}
N 21640 -14180 21640 -14090 {
lab=O3}
N 21640 -14090 21640 -13940 {
lab=O3}
N 22270 -14300 22270 -14250 {
lab=RBLX[4]}
N 21930 -14240 21930 -14190 { lab=VDD}
N 21930 -14160 21940 -14160 { lab=VDD}
N 21940 -14190 21940 -14160 { lab=VDD}
N 21930 -14190 21940 -14190 { lab=VDD}
N 21840 -14160 21890 -14160 { lab=PRE[4]}
N 21930 -14130 21930 -14080 { lab=O4}
N 22250 -14200 22270 -14200 { lab=VSS}
N 22310 -14200 22340 -14200 { lab=EN[4]}
N 21930 -14080 22170 -14080 { lab=O4}
N 22270 -14250 22270 -14230 {
lab=RBLX[4]}
N 22170 -14080 22270 -14080 {
lab=O4}
N 22270 -14170 22270 -14080 {
lab=O4}
N 22270 -14080 22270 -13930 {
lab=O4}
N 22970 -14300 22970 -14250 {
lab=RBLX[5]}
N 22630 -14240 22630 -14190 { lab=VDD}
N 22630 -14160 22640 -14160 { lab=VDD}
N 22640 -14190 22640 -14160 { lab=VDD}
N 22630 -14190 22640 -14190 { lab=VDD}
N 22540 -14160 22590 -14160 { lab=PRE[5]}
N 22630 -14130 22630 -14080 { lab=O5}
N 22950 -14200 22970 -14200 { lab=VSS}
N 23010 -14200 23040 -14200 { lab=EN[5]}
N 22630 -14080 22870 -14080 { lab=O5}
N 22970 -14250 22970 -14230 {
lab=RBLX[5]}
N 22870 -14080 22970 -14080 {
lab=O5}
N 22970 -14170 22970 -14080 {
lab=O5}
N 22970 -14080 22970 -13930 {
lab=O5}
N 23640 -14300 23640 -14250 {
lab=RBLX[6]}
N 23300 -14240 23300 -14190 { lab=VDD}
N 23300 -14160 23310 -14160 { lab=VDD}
N 23310 -14190 23310 -14160 { lab=VDD}
N 23300 -14190 23310 -14190 { lab=VDD}
N 23210 -14160 23260 -14160 { lab=PRE[6]}
N 23300 -14130 23300 -14080 { lab=O6}
N 23620 -14200 23640 -14200 { lab=VSS}
N 23680 -14200 23710 -14200 { lab=EN[6]}
N 23300 -14080 23540 -14080 { lab=O6}
N 23640 -14250 23640 -14230 {
lab=RBLX[6]}
N 23540 -14080 23640 -14080 {
lab=O6}
N 23640 -14170 23640 -14080 {
lab=O6}
N 23640 -14080 23640 -13930 {
lab=O6}
N 24340 -14300 24340 -14250 {
lab=RBLX[7]}
N 24000 -14240 24000 -14190 { lab=VDD}
N 24000 -14160 24010 -14160 { lab=VDD}
N 24010 -14190 24010 -14160 { lab=VDD}
N 24000 -14190 24010 -14190 { lab=VDD}
N 23910 -14160 23960 -14160 { lab=PRE[7]}
N 24000 -14130 24000 -14080 { lab=O7}
N 24320 -14200 24340 -14200 { lab=VSS}
N 24380 -14200 24410 -14200 { lab=EN[7]}
N 24000 -14080 24240 -14080 { lab=O7}
N 24340 -14250 24340 -14230 {
lab=RBLX[7]}
N 24240 -14080 24340 -14080 {
lab=O7}
N 24340 -14170 24340 -14080 {
lab=O7}
N 24340 -14080 24340 -13930 {
lab=O7}
N 24930 -14310 24930 -14260 {
lab=RBLX[8]}
N 24590 -14250 24590 -14200 { lab=VDD}
N 24590 -14170 24600 -14170 { lab=VDD}
N 24600 -14200 24600 -14170 { lab=VDD}
N 24590 -14200 24600 -14200 { lab=VDD}
N 24500 -14170 24550 -14170 { lab=PRE[8]}
N 24590 -14140 24590 -14090 { lab=O8}
N 24910 -14210 24930 -14210 { lab=VSS}
N 24970 -14210 25000 -14210 { lab=EN[8]}
N 24590 -14090 24830 -14090 { lab=O8}
N 24930 -14260 24930 -14240 {
lab=RBLX[8]}
N 24830 -14090 24930 -14090 {
lab=O8}
N 24930 -14180 24930 -14090 {
lab=O8}
N 24930 -14090 24930 -13940 {
lab=O8}
N 25630 -14310 25630 -14260 {
lab=RBLX[9]}
N 25290 -14250 25290 -14200 { lab=VDD}
N 25290 -14170 25300 -14170 { lab=VDD}
N 25300 -14200 25300 -14170 { lab=VDD}
N 25290 -14200 25300 -14200 { lab=VDD}
N 25200 -14170 25250 -14170 { lab=PRE[9]}
N 25290 -14140 25290 -14090 { lab=O9}
N 25610 -14210 25630 -14210 { lab=VSS}
N 25670 -14210 25700 -14210 { lab=EN[9]}
N 25290 -14090 25530 -14090 { lab=O9}
N 25630 -14260 25630 -14240 {
lab=RBLX[9]}
N 25530 -14090 25630 -14090 {
lab=O9}
N 25630 -14180 25630 -14090 {
lab=O9}
N 25630 -14090 25630 -13940 {
lab=O9}
N 26300 -14310 26300 -14260 {
lab=RBLX[10]}
N 25960 -14250 25960 -14200 { lab=VDD}
N 25960 -14170 25970 -14170 { lab=VDD}
N 25970 -14200 25970 -14170 { lab=VDD}
N 25960 -14200 25970 -14200 { lab=VDD}
N 25870 -14170 25920 -14170 { lab=PRE[10]}
N 25960 -14140 25960 -14090 { lab=O10}
N 26280 -14210 26300 -14210 { lab=VSS}
N 26340 -14210 26370 -14210 { lab=EN[10]}
N 25960 -14090 26200 -14090 { lab=O10}
N 26300 -14260 26300 -14240 {
lab=RBLX[10]}
N 26200 -14090 26300 -14090 {
lab=O10}
N 26300 -14180 26300 -14090 {
lab=O10}
N 26300 -14090 26300 -13940 {
lab=O10}
N 27000 -14310 27000 -14260 {
lab=RBLX[11]}
N 26660 -14250 26660 -14200 { lab=VDD}
N 26660 -14170 26670 -14170 { lab=VDD}
N 26670 -14200 26670 -14170 { lab=VDD}
N 26660 -14200 26670 -14200 { lab=VDD}
N 26570 -14170 26620 -14170 { lab=PRE[11]}
N 26660 -14140 26660 -14090 { lab=O11}
N 26980 -14210 27000 -14210 { lab=VSS}
N 27040 -14210 27070 -14210 { lab=EN[11]}
N 26660 -14090 26900 -14090 { lab=O11}
N 27000 -14260 27000 -14240 {
lab=RBLX[11]}
N 26900 -14090 27000 -14090 {
lab=O11}
N 27000 -14180 27000 -14090 {
lab=O11}
N 27000 -14090 27000 -13940 {
lab=O11}
N 27630 -14300 27630 -14250 {
lab=RBLX[12]}
N 27290 -14240 27290 -14190 { lab=VDD}
N 27290 -14160 27300 -14160 { lab=VDD}
N 27300 -14190 27300 -14160 { lab=VDD}
N 27290 -14190 27300 -14190 { lab=VDD}
N 27200 -14160 27250 -14160 { lab=PRE[12]}
N 27290 -14130 27290 -14080 { lab=O12}
N 27610 -14200 27630 -14200 { lab=VSS}
N 27670 -14200 27700 -14200 { lab=EN[12]}
N 27290 -14080 27530 -14080 { lab=O12}
N 27630 -14250 27630 -14230 {
lab=RBLX[12]}
N 27530 -14080 27630 -14080 {
lab=O12}
N 27630 -14170 27630 -14080 {
lab=O12}
N 27630 -14080 27630 -13930 {
lab=O12}
N 28330 -14300 28330 -14250 {
lab=RBLX[13]}
N 27990 -14240 27990 -14190 { lab=VDD}
N 27990 -14160 28000 -14160 { lab=VDD}
N 28000 -14190 28000 -14160 { lab=VDD}
N 27990 -14190 28000 -14190 { lab=VDD}
N 27900 -14160 27950 -14160 { lab=PRE[13]}
N 27990 -14130 27990 -14080 { lab=O13}
N 28310 -14200 28330 -14200 { lab=VSS}
N 28370 -14200 28400 -14200 { lab=EN[13]}
N 27990 -14080 28230 -14080 { lab=O13}
N 28330 -14250 28330 -14230 {
lab=RBLX[13]}
N 28230 -14080 28330 -14080 {
lab=O13}
N 28330 -14170 28330 -14080 {
lab=O13}
N 28330 -14080 28330 -13930 {
lab=O13}
N 29030 -14310 29030 -14260 {
lab=RBLX[14]}
N 28690 -14250 28690 -14200 { lab=VDD}
N 28690 -14170 28700 -14170 { lab=VDD}
N 28700 -14200 28700 -14170 { lab=VDD}
N 28690 -14200 28700 -14200 { lab=VDD}
N 28600 -14170 28650 -14170 { lab=PRE[14]}
N 28690 -14140 28690 -14090 { lab=O14}
N 29010 -14210 29030 -14210 { lab=VSS}
N 29070 -14210 29100 -14210 { lab=EN[14]}
N 28690 -14090 28930 -14090 { lab=O14}
N 29030 -14260 29030 -14240 {
lab=RBLX[14]}
N 28930 -14090 29030 -14090 {
lab=O14}
N 29030 -14180 29030 -14090 {
lab=O14}
N 29030 -14090 29030 -13940 {
lab=O14}
N 29700 -14300 29700 -14250 {
lab=RBLX[15]}
N 29360 -14240 29360 -14190 { lab=VDD}
N 29360 -14160 29370 -14160 { lab=VDD}
N 29370 -14190 29370 -14160 { lab=VDD}
N 29360 -14190 29370 -14190 { lab=VDD}
N 29270 -14160 29320 -14160 { lab=PRE[15]}
N 29360 -14130 29360 -14080 { lab=O15}
N 29680 -14200 29700 -14200 { lab=VSS}
N 29740 -14200 29770 -14200 { lab=EN[15]}
N 29360 -14080 29600 -14080 { lab=O15}
N 29700 -14250 29700 -14230 {
lab=RBLX[15]}
N 29600 -14080 29700 -14080 {
lab=O15}
N 29700 -14170 29700 -14080 {
lab=O15}
N 29700 -14080 29700 -13930 {
lab=O15}
N 19380 -14980 19760 -14980 {
lab=RBLX[0]}
N 20050 -14980 20430 -14980 {
lab=RBLX[1]}
N 20720 -14980 21100 -14980 {
lab=RBLX[2]}
N 21390 -14980 21770 -14980 {
lab=RBLX[3]}
N 22070 -14990 22450 -14990 {
lab=RBLX[4]}
N 22740 -14990 23120 -14990 {
lab=RBLX[5]}
N 23410 -14990 23790 -14990 {
lab=RBLX[6]}
N 24080 -14990 24460 -14990 {
lab=RBLX[7]}
N 24700 -14980 25080 -14980 {
lab=RBLX[8]}
N 25370 -14980 25750 -14980 {
lab=RBLX[9]}
N 26040 -14980 26420 -14980 {
lab=RBLX[10]}
N 26820 -14980 27200 -14980 {
lab=RBLX[11]}
N 27460 -14990 27840 -14990 {
lab=RBLX[12]}
N 28150 -14990 28530 -14990 {
lab=RBLX[13]}
N 28870 -15000 29250 -15000 {
lab=RBLX[14]}
N 29540 -15000 29920 -15000 {
lab=RBLX[15]}
N 19570 -13940 19570 -13800 {
lab=O0}
N 19570 -14090 19570 -14040 {
lab=O0}
N 19570 -13980 19570 -13940 {
lab=O0}
N 21610 -14490 21610 -14460 {
lab=SA_OUT[3]}
N 20270 -13940 20270 -13800 {
lab=O1}
N 20940 -13940 20940 -13800 {
lab=O2}
N 20940 -13800 20940 -13790 {
lab=O2}
N 21080 -13820 21080 -13790 {
lab=Iref3}
N 21040 -13820 21040 -13790 {
lab=Iref2}
N 21010 -13820 21010 -13790 {
lab=Iref1}
N 20980 -13830 20980 -13790 {
lab=Iref0}
N 20900 -13820 20900 -13790 {
lab=VSS}
N 20880 -13820 20880 -13790 {
lab=VDD}
N 20820 -13710 20850 -13710 {
lab=SAEN}
N 20820 -13650 20850 -13650 {
lab=VCLP}
N 20820 -13600 20850 -13600 {
lab=PRE_CLSA}
N 20890 -13510 20890 -13470 {
lab=ADC2_OUT[3]}
N 20930 -13510 20930 -13470 {
lab=ADC2_OUT[2]}
N 20970 -13510 20970 -13460 {
lab=ADC2_OUT[1]}
N 21010 -13510 21010 -13470 {
lab=ADC2_OUT[0]}
N 21640 -13940 21640 -13800 {
lab=O3}
N 21640 -13800 21640 -13790 {
lab=O3}
N 21780 -13820 21780 -13790 {
lab=Iref3}
N 21740 -13820 21740 -13790 {
lab=Iref2}
N 21710 -13820 21710 -13790 {
lab=Iref1}
N 21680 -13830 21680 -13790 {
lab=Iref0}
N 21600 -13820 21600 -13790 {
lab=VSS}
N 21580 -13820 21580 -13790 {
lab=VDD}
N 21520 -13710 21550 -13710 {
lab=SAEN}
N 21520 -13650 21550 -13650 {
lab=VCLP}
N 21520 -13600 21550 -13600 {
lab=PRE_CLSA}
N 21590 -13510 21590 -13470 {
lab=ADC3_OUT[3]}
N 21630 -13510 21630 -13470 {
lab=ADC3_OUT[2]}
N 21670 -13510 21670 -13460 {
lab=ADC3_OUT[1]}
N 21710 -13510 21710 -13470 {
lab=ADC3_OUT[0]}
N 22270 -13930 22270 -13790 {
lab=O4}
N 22270 -13790 22270 -13780 {
lab=O4}
N 22410 -13810 22410 -13780 {
lab=Iref3}
N 22370 -13810 22370 -13780 {
lab=Iref2}
N 22340 -13810 22340 -13780 {
lab=Iref1}
N 22310 -13820 22310 -13780 {
lab=Iref0}
N 22230 -13810 22230 -13780 {
lab=VSS}
N 22210 -13810 22210 -13780 {
lab=VDD}
N 22150 -13700 22180 -13700 {
lab=SAEN}
N 22150 -13640 22180 -13640 {
lab=VCLP}
N 22150 -13590 22180 -13590 {
lab=PRE_CLSA}
N 22220 -13500 22220 -13460 {
lab=ADC4_OUT[3]}
N 22260 -13500 22260 -13460 {
lab=ADC4_OUT[2]}
N 22300 -13500 22300 -13450 {
lab=ADC4_OUT[1]}
N 22340 -13500 22340 -13460 {
lab=ADC4_OUT[0]}
N 22970 -13930 22970 -13790 {
lab=O5}
N 22970 -13790 22970 -13780 {
lab=O5}
N 23110 -13810 23110 -13780 {
lab=Iref3}
N 23070 -13810 23070 -13780 {
lab=Iref2}
N 23040 -13810 23040 -13780 {
lab=Iref1}
N 23010 -13820 23010 -13780 {
lab=Iref0}
N 22930 -13810 22930 -13780 {
lab=VSS}
N 22910 -13810 22910 -13780 {
lab=VDD}
N 22850 -13700 22880 -13700 {
lab=SAEN}
N 22850 -13640 22880 -13640 {
lab=VCLP}
N 22850 -13590 22880 -13590 {
lab=PRE_CLSA}
N 22920 -13500 22920 -13460 {
lab=ADC5_OUT[3]}
N 22960 -13500 22960 -13460 {
lab=ADC5_OUT[2]}
N 23000 -13500 23000 -13450 {
lab=ADC5_OUT[1]}
N 23040 -13500 23040 -13460 {
lab=ADC5_OUT[0]}
N 23640 -13920 23640 -13780 {
lab=#net1}
N 23640 -13780 23640 -13770 {
lab=#net1}
N 23780 -13800 23780 -13770 {
lab=Iref3}
N 23740 -13800 23740 -13770 {
lab=Iref2}
N 23710 -13800 23710 -13770 {
lab=Iref1}
N 23680 -13810 23680 -13770 {
lab=Iref0}
N 23600 -13800 23600 -13770 {
lab=VSS}
N 23580 -13800 23580 -13770 {
lab=VDD}
N 23520 -13690 23550 -13690 {
lab=SAEN}
N 23520 -13630 23550 -13630 {
lab=VCLP}
N 23520 -13580 23550 -13580 {
lab=PRE_CLSA}
N 24340 -13930 24340 -13790 {
lab=O7}
N 24340 -13790 24340 -13780 {
lab=O7}
N 24480 -13810 24480 -13780 {
lab=Iref3}
N 24440 -13810 24440 -13780 {
lab=Iref2}
N 24410 -13810 24410 -13780 {
lab=Iref1}
N 24380 -13820 24380 -13780 {
lab=Iref0}
N 24300 -13810 24300 -13780 {
lab=VSS}
N 24280 -13810 24280 -13780 {
lab=VDD}
N 24220 -13700 24250 -13700 {
lab=SAEN}
N 24220 -13640 24250 -13640 {
lab=VCLP}
N 24220 -13590 24250 -13590 {
lab=PRE_CLSA}
N 24290 -13500 24290 -13460 {
lab=ADC7_OUT[3]}
N 24330 -13500 24330 -13460 {
lab=ADC7_OUT[2]}
N 24370 -13500 24370 -13450 {
lab=ADC7_OUT[1]}
N 24410 -13500 24410 -13460 {
lab=ADC7_OUT[0]}
N 24930 -13940 24930 -13800 {
lab=O8}
N 24930 -13800 24930 -13790 {
lab=O8}
N 25070 -13820 25070 -13790 {
lab=Iref3}
N 25030 -13820 25030 -13790 {
lab=Iref2}
N 25000 -13820 25000 -13790 {
lab=Iref1}
N 24970 -13830 24970 -13790 {
lab=Iref0}
N 24890 -13820 24890 -13790 {
lab=VSS}
N 24870 -13820 24870 -13790 {
lab=VDD}
N 24810 -13710 24840 -13710 {
lab=SAEN}
N 24810 -13650 24840 -13650 {
lab=VCLP}
N 24810 -13600 24840 -13600 {
lab=PRE_CLSA}
N 24880 -13510 24880 -13470 {
lab=ADC8_OUT[3]}
N 24920 -13510 24920 -13470 {
lab=ADC8_OUT[2]}
N 24960 -13510 24960 -13460 {
lab=ADC8_OUT[1]}
N 25000 -13510 25000 -13470 {
lab=ADC8_OUT[0]}
N 25630 -13940 25630 -13800 {
lab=O9}
N 25630 -13800 25630 -13790 {
lab=O9}
N 25770 -13820 25770 -13790 {
lab=Iref3}
N 25730 -13820 25730 -13790 {
lab=Iref2}
N 25700 -13820 25700 -13790 {
lab=Iref1}
N 25670 -13830 25670 -13790 {
lab=Iref0}
N 25590 -13820 25590 -13790 {
lab=VSS}
N 25570 -13820 25570 -13790 {
lab=VDD}
N 25510 -13710 25540 -13710 {
lab=SAEN}
N 25510 -13650 25540 -13650 {
lab=VCLP}
N 25510 -13600 25540 -13600 {
lab=PRE_CLSA}
N 25580 -13510 25580 -13470 {
lab=ADC9_OUT[3]}
N 25620 -13510 25620 -13470 {
lab=ADC9_OUT[2]}
N 25660 -13510 25660 -13460 {
lab=ADC9_OUT[1]}
N 25700 -13510 25700 -13470 {
lab=ADC9_OUT[0]}
N 26300 -13940 26300 -13800 {
lab=O10}
N 26300 -13800 26300 -13790 {
lab=O10}
N 26440 -13820 26440 -13790 {
lab=Iref3}
N 26400 -13820 26400 -13790 {
lab=Iref2}
N 26370 -13820 26370 -13790 {
lab=Iref1}
N 26340 -13830 26340 -13790 {
lab=Iref0}
N 26260 -13820 26260 -13790 {
lab=VSS}
N 26240 -13820 26240 -13790 {
lab=VDD}
N 26180 -13710 26210 -13710 {
lab=SAEN}
N 26180 -13650 26210 -13650 {
lab=VCLP}
N 26180 -13600 26210 -13600 {
lab=PRE_CLSA}
N 26250 -13510 26250 -13470 {
lab=ADC10_OUT[3]}
N 26290 -13510 26290 -13470 {
lab=ADC10_OUT[2]}
N 26330 -13510 26330 -13460 {
lab=ADC10_OUT[1]}
N 26370 -13510 26370 -13470 {
lab=ADC10_OUT[0]}
N 27000 -13940 27000 -13800 {
lab=O11}
N 27000 -13800 27000 -13790 {
lab=O11}
N 27140 -13820 27140 -13790 {
lab=Iref3}
N 27100 -13820 27100 -13790 {
lab=Iref2}
N 27070 -13820 27070 -13790 {
lab=Iref1}
N 27040 -13830 27040 -13790 {
lab=Iref0}
N 26960 -13820 26960 -13790 {
lab=VSS}
N 26940 -13820 26940 -13790 {
lab=VDD}
N 26880 -13710 26910 -13710 {
lab=SAEN}
N 26880 -13650 26910 -13650 {
lab=VCLP}
N 26880 -13600 26910 -13600 {
lab=PRE_CLSA}
N 26950 -13510 26950 -13470 {
lab=ADC11_OUT[3]}
N 26990 -13510 26990 -13470 {
lab=ADC0_OUT[2]}
N 27030 -13510 27030 -13460 {
lab=ADC0_OUT[1]}
N 27070 -13510 27070 -13470 {
lab=ADC0_OUT[0]}
N 27630 -13930 27630 -13790 {
lab=O12}
N 27630 -13790 27630 -13780 {
lab=O12}
N 27770 -13810 27770 -13780 {
lab=Iref3}
N 27730 -13810 27730 -13780 {
lab=Iref2}
N 27700 -13810 27700 -13780 {
lab=Iref1}
N 27670 -13820 27670 -13780 {
lab=Iref0}
N 27590 -13810 27590 -13780 {
lab=VSS}
N 27570 -13810 27570 -13780 {
lab=VDD}
N 27510 -13700 27540 -13700 {
lab=SAEN}
N 27510 -13640 27540 -13640 {
lab=VCLP}
N 27510 -13590 27540 -13590 {
lab=PRE_CLSA}
N 27580 -13500 27580 -13460 {
lab=ADC0_OUT[3]}
N 27620 -13500 27620 -13460 {
lab=ADC0_OUT[2]}
N 27660 -13500 27660 -13450 {
lab=ADC0_OUT[1]}
N 27700 -13500 27700 -13460 {
lab=ADC0_OUT[0]}
N 28330 -13930 28330 -13790 {
lab=O13}
N 28330 -13790 28330 -13780 {
lab=O13}
N 28470 -13810 28470 -13780 {
lab=Iref3}
N 28430 -13810 28430 -13780 {
lab=Iref2}
N 28400 -13810 28400 -13780 {
lab=Iref1}
N 28370 -13820 28370 -13780 {
lab=Iref0}
N 28290 -13810 28290 -13780 {
lab=VSS}
N 28270 -13810 28270 -13780 {
lab=VDD}
N 28210 -13700 28240 -13700 {
lab=SAEN}
N 28210 -13640 28240 -13640 {
lab=VCLP}
N 28210 -13590 28240 -13590 {
lab=PRE_CLSA}
N 28280 -13500 28280 -13460 {
lab=ADC0_OUT[3]}
N 28320 -13500 28320 -13460 {
lab=ADC0_OUT[2]}
N 28360 -13500 28360 -13450 {
lab=ADC0_OUT[1]}
N 28400 -13500 28400 -13460 {
lab=ADC0_OUT[0]}
N 29030 -13940 29030 -13800 {
lab=O14}
N 29030 -13800 29030 -13790 {
lab=O14}
N 29170 -13820 29170 -13790 {
lab=Iref3}
N 29130 -13820 29130 -13790 {
lab=Iref2}
N 29100 -13820 29100 -13790 {
lab=Iref1}
N 29070 -13830 29070 -13790 {
lab=Iref0}
N 28990 -13820 28990 -13790 {
lab=VSS}
N 28970 -13820 28970 -13790 {
lab=VDD}
N 28910 -13710 28940 -13710 {
lab=SAEN}
N 28910 -13650 28940 -13650 {
lab=VCLP}
N 28910 -13600 28940 -13600 {
lab=PRE_CLSA}
N 28980 -13510 28980 -13470 {
lab=ADC0_OUT[3]}
N 29020 -13510 29020 -13470 {
lab=ADC0_OUT[2]}
N 29060 -13510 29060 -13460 {
lab=ADC0_OUT[1]}
N 29100 -13510 29100 -13470 {
lab=ADC0_OUT[0]}
N 29700 -13930 29700 -13790 {
lab=O15}
N 29700 -13790 29700 -13780 {
lab=O15}
N 29840 -13810 29840 -13780 {
lab=Iref3}
N 29800 -13810 29800 -13780 {
lab=Iref2}
N 29770 -13810 29770 -13780 {
lab=Iref1}
N 29740 -13820 29740 -13780 {
lab=Iref0}
N 29660 -13810 29660 -13780 {
lab=VSS}
N 29640 -13810 29640 -13780 {
lab=VDD}
N 29580 -13700 29610 -13700 {
lab=SAEN}
N 29580 -13640 29610 -13640 {
lab=VCLP}
N 29580 -13590 29610 -13590 {
lab=PRE_CLSA}
N 29650 -13500 29650 -13460 {
lab=ADC0_OUT[3]}
N 29690 -13500 29690 -13460 {
lab=ADC0_OUT[2]}
N 29730 -13500 29730 -13450 {
lab=ADC0_OUT[1]}
N 29770 -13500 29770 -13460 {
lab=ADC0_OUT[0]}
N 19530 -13830 19530 -13800 {
lab=VSS}
N 19510 -13830 19510 -13800 {
lab=VDD}
N 19450 -13720 19480 -13720 {
lab=SAEN}
N 19450 -13660 19480 -13660 {
lab=VCLP}
N 19450 -13610 19480 -13610 {
lab=PRE_CLSA}
N 19520 -13520 19520 -13480 {
lab=ADC0_OUT[3]}
N 19560 -13520 19560 -13480 {
lab=ADC0_OUT[2]}
N 19600 -13520 19600 -13470 {
lab=ADC0_OUT[1]}
N 19640 -13520 19640 -13480 {
lab=ADC0_OUT[0]}
N 20270 -13800 20270 -13790 {
lab=O1}
N 20410 -13820 20410 -13790 {
lab=Iref3}
N 20370 -13820 20370 -13790 {
lab=Iref2}
N 20340 -13820 20340 -13790 {
lab=Iref1}
N 20310 -13830 20310 -13790 {
lab=Iref0}
N 20230 -13820 20230 -13790 {
lab=VSS}
N 20210 -13820 20210 -13790 {
lab=VDD}
N 20150 -13710 20180 -13710 {
lab=SAEN}
N 20150 -13650 20180 -13650 {
lab=VCLP}
N 20150 -13600 20180 -13600 {
lab=PRE_CLSA}
N 20220 -13510 20220 -13470 {
lab=ADC1_OUT[3]}
N 20260 -13510 20260 -13470 {
lab=ADC1_OUT[2]}
N 20300 -13510 20300 -13460 {
lab=ADC1_OUT[1]}
N 20340 -13510 20340 -13470 {
lab=ADC1_OUT[0]}
N 19610 -13830 19610 -13800 {
lab=Iref0}
N 19640 -13830 19640 -13800 {
lab=Iref1}
N 19670 -13830 19670 -13800 {
lab=Iref2}
N 19710 -13830 19710 -13800 {
lab=Iref3}
N 19570 -14040 19570 -13980 {
lab=O0}
C {devices/ipin.sym} 18190 -15640 0 0 {name=p9 lab=WWL[0:15]}
C {devices/ipin.sym} 18180 -15530 0 0 {name=p10 lab=RWL[0:15]}
C {devices/ipin.sym} 18180 -15490 0 0 {name=p11 lab=RWLB[0:15]}
C {devices/iopin.sym} 18180 -15710 0 0 {name=p14 lab=VDD}
C {devices/iopin.sym} 18180 -15680 0 0 {name=p15 lab=VSS}
C {devices/lab_pin.sym} 19480 -15430 2 1 {name=l239 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 19590 -15430 2 0 {name=l240 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 19540 -15060 0 1 {name=l246 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 19370 -15330 0 0 {name=l247 sig_type=std_logic lab=BL[0]}
C {devices/lab_pin.sym} 19750 -15330 2 0 {name=l248 sig_type=std_logic lab=BLB[0]}
C {devices/lab_pin.sym} 19750 -15280 2 0 {name=l249 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 19370 -15280 0 0 {name=l250 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 20150 -15430 2 1 {name=l251 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 20260 -15430 2 0 {name=l252 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20210 -15060 0 1 {name=l253 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 20040 -15330 0 0 {name=l254 sig_type=std_logic lab=BL[1]}
C {devices/lab_pin.sym} 20420 -15330 2 0 {name=l255 sig_type=std_logic lab=BLB[1]}
C {devices/lab_pin.sym} 20420 -15280 2 0 {name=l256 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 20040 -15280 0 0 {name=l257 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 20820 -15430 2 1 {name=l258 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 20930 -15430 2 0 {name=l259 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20880 -15060 0 1 {name=l260 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 20710 -15330 0 0 {name=l261 sig_type=std_logic lab=BL[2]}
C {devices/lab_pin.sym} 21090 -15330 2 0 {name=l262 sig_type=std_logic lab=BLB[2]}
C {devices/lab_pin.sym} 21090 -15280 2 0 {name=l263 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 20710 -15280 0 0 {name=l264 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 21490 -15430 2 1 {name=l265 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 21600 -15430 2 0 {name=l266 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 21550 -15060 0 1 {name=l267 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 21380 -15330 0 0 {name=l268 sig_type=std_logic lab=BL[3]}
C {devices/lab_pin.sym} 21760 -15330 2 0 {name=l269 sig_type=std_logic lab=BLB[3]}
C {devices/lab_pin.sym} 21760 -15280 2 0 {name=l270 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 21380 -15280 0 0 {name=l271 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 22170 -15440 2 1 {name=l272 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 22280 -15440 2 0 {name=l273 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 22230 -15070 3 0 {name=l510 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 22060 -15340 0 0 {name=l511 sig_type=std_logic lab=BL[4]}
C {devices/lab_pin.sym} 22440 -15340 2 0 {name=l512 sig_type=std_logic lab=BLB[4]}
C {devices/lab_pin.sym} 22440 -15290 2 0 {name=l513 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 22060 -15290 0 0 {name=l514 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 22840 -15440 1 0 {name=l515 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 22950 -15440 1 0 {name=l516 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 22900 -15070 0 1 {name=l517 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 22730 -15340 0 0 {name=l518 sig_type=std_logic lab=BL[5]}
C {devices/lab_pin.sym} 23110 -15340 2 0 {name=l519 sig_type=std_logic lab=BLB[5]}
C {devices/lab_pin.sym} 23110 -15290 2 0 {name=l520 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 22730 -15290 0 0 {name=l521 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 23510 -15440 2 1 {name=l522 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 23620 -15440 2 0 {name=l523 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 23570 -15070 0 1 {name=l524 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 23400 -15340 0 0 {name=l525 sig_type=std_logic lab=BL[6]}
C {devices/lab_pin.sym} 23780 -15340 2 0 {name=l526 sig_type=std_logic lab=BLB[6]}
C {devices/lab_pin.sym} 23780 -15290 2 0 {name=l527 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 23400 -15290 0 0 {name=l528 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 24180 -15440 2 1 {name=l529 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 24290 -15440 2 0 {name=l530 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 24240 -15070 0 1 {name=l531 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 24070 -15340 0 0 {name=l532 sig_type=std_logic lab=BL[7]}
C {devices/lab_pin.sym} 24450 -15340 2 0 {name=l533 sig_type=std_logic lab=BLB[7]}
C {devices/lab_pin.sym} 24450 -15290 2 0 {name=l534 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 24070 -15290 0 0 {name=l535 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 24800 -15430 2 1 {name=l536 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 24910 -15430 2 0 {name=l537 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 24860 -15060 0 1 {name=l538 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 24690 -15330 0 0 {name=l539 sig_type=std_logic lab=BL[8]}
C {devices/lab_pin.sym} 25070 -15330 2 0 {name=l540 sig_type=std_logic lab=BLB[8]}
C {devices/lab_pin.sym} 25070 -15280 2 0 {name=l541 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 24690 -15280 0 0 {name=l542 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 25470 -15430 2 1 {name=l543 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 25580 -15430 2 0 {name=l544 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 25530 -15060 0 1 {name=l545 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 25360 -15330 0 0 {name=l546 sig_type=std_logic lab=BL[9]}
C {devices/lab_pin.sym} 25740 -15330 2 0 {name=l547 sig_type=std_logic lab=BLB[9]}
C {devices/lab_pin.sym} 25740 -15280 2 0 {name=l548 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 25360 -15280 0 0 {name=l549 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 26140 -15430 0 0 {name=l550 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 26250 -15430 2 0 {name=l551 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 26200 -15060 0 1 {name=l552 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 26030 -15330 0 0 {name=l553 sig_type=std_logic lab=BL[10]}
C {devices/lab_pin.sym} 26410 -15330 2 0 {name=l554 sig_type=std_logic lab=BLB[10]}
C {devices/lab_pin.sym} 26410 -15280 2 0 {name=l555 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 26030 -15280 0 0 {name=l556 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 26920 -15430 2 1 {name=l557 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 27030 -15430 2 0 {name=l558 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 26980 -15060 2 0 {name=l559 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 26810 -15330 0 0 {name=l560 sig_type=std_logic lab=BL[11]}
C {devices/lab_pin.sym} 27190 -15330 2 0 {name=l561 sig_type=std_logic lab=BLB[11]}
C {devices/lab_pin.sym} 27190 -15280 2 0 {name=l562 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 26810 -15280 0 0 {name=l563 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 27560 -15440 2 1 {name=l564 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 27670 -15440 2 0 {name=l565 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 27620 -15070 2 0 {name=l566 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 27450 -15340 0 0 {name=l567 sig_type=std_logic lab=BL[12]}
C {devices/lab_pin.sym} 27830 -15340 2 0 {name=l568 sig_type=std_logic lab=BLB[12]}
C {devices/lab_pin.sym} 27830 -15290 2 0 {name=l569 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 27450 -15290 0 0 {name=l570 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 28250 -15440 2 1 {name=l571 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 28360 -15440 2 0 {name=l572 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 28310 -15070 0 1 {name=l573 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 28140 -15340 0 0 {name=l574 sig_type=std_logic lab=BL[13]}
C {devices/lab_pin.sym} 28520 -15340 2 0 {name=l575 sig_type=std_logic lab=BLB[13]}
C {devices/lab_pin.sym} 28520 -15290 2 0 {name=l576 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 28140 -15290 0 0 {name=l577 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 28970 -15450 0 0 {name=l578 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 29080 -15450 2 0 {name=l579 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 29030 -15080 0 1 {name=l580 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 28860 -15350 0 0 {name=l581 sig_type=std_logic lab=BL[14]}
C {devices/lab_pin.sym} 29240 -15350 2 0 {name=l582 sig_type=std_logic lab=BLB[14]}
C {devices/lab_pin.sym} 29240 -15300 2 0 {name=l583 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 28860 -15300 0 0 {name=l584 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 29640 -15450 0 0 {name=l585 sig_type=std_logic lab=WWL[0:15]}
C {devices/lab_pin.sym} 29750 -15450 0 1 {name=l586 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 29700 -15080 0 1 {name=l587 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 29530 -15350 0 0 {name=l588 sig_type=std_logic lab=BL[15]}
C {devices/lab_pin.sym} 29910 -15350 2 0 {name=l589 sig_type=std_logic lab=BLB[15]}
C {devices/lab_pin.sym} 29910 -15300 2 0 {name=l590 sig_type=std_logic lab=RWLB[0:15]}
C {devices/lab_pin.sym} 29530 -15300 0 0 {name=l591 sig_type=std_logic lab=RWL[0:15]}
C {devices/lab_pin.sym} 19580 -15700 2 0 {name=l592 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 19520 -15700 0 0 {name=l593 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 19420 -15630 0 0 {name=l594 sig_type=std_logic lab=BL[0]}
C {devices/lab_pin.sym} 19660 -15630 2 0 {name=l595 sig_type=std_logic lab=BLB[0]}
C {devices/lab_pin.sym} 19530 -15980 2 0 {name=l596 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 19530 -15810 3 0 {name=l597 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 19410 -15880 0 0 {name=l598 sig_type=std_logic lab=BL[0]}
C {devices/lab_pin.sym} 19660 -15880 2 0 {name=l599 sig_type=std_logic lab=BLB[0]}
C {devices/lab_pin.sym} 19410 -15910 0 0 {name=l600 sig_type=std_logic lab=Din[0]}
C {devices/lab_pin.sym} 19410 -15930 0 0 {name=l601 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 20220 -15700 2 0 {name=l602 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20160 -15700 0 0 {name=l603 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 20060 -15630 0 0 {name=l604 sig_type=std_logic lab=BL[1]}
C {devices/lab_pin.sym} 20300 -15630 2 0 {name=l605 sig_type=std_logic lab=BLB[1]}
C {devices/lab_pin.sym} 20160 -15980 2 0 {name=l606 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20160 -15810 0 1 {name=l607 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 20040 -15880 0 0 {name=l608 sig_type=std_logic lab=BL[1]}
C {devices/lab_pin.sym} 20290 -15880 2 0 {name=l609 sig_type=std_logic lab=BLB[1]}
C {devices/lab_pin.sym} 20040 -15910 0 0 {name=l610 sig_type=std_logic lab=Din[1]}
C {devices/lab_pin.sym} 20040 -15930 0 0 {name=l611 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 20890 -15700 2 0 {name=l612 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20830 -15700 0 0 {name=l613 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 20730 -15630 0 0 {name=l614 sig_type=std_logic lab=BL[2]}
C {devices/lab_pin.sym} 20970 -15630 2 0 {name=l615 sig_type=std_logic lab=BLB[2]}
C {devices/lab_pin.sym} 20840 -15980 2 0 {name=l616 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20840 -15810 2 0 {name=l617 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 20720 -15880 0 0 {name=l618 sig_type=std_logic lab=BL[2]}
C {devices/lab_pin.sym} 20970 -15880 2 0 {name=l619 sig_type=std_logic lab=BLB[2]}
C {devices/lab_pin.sym} 20720 -15910 0 0 {name=l620 sig_type=std_logic lab=Din[2]}
C {devices/lab_pin.sym} 20720 -15930 0 0 {name=l621 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 21530 -15700 2 0 {name=l622 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 21470 -15700 0 0 {name=l623 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 21370 -15630 0 0 {name=l624 sig_type=std_logic lab=BL[3]}
C {devices/lab_pin.sym} 21610 -15630 2 0 {name=l625 sig_type=std_logic lab=BLB[3]}
C {devices/lab_pin.sym} 21480 -15980 2 0 {name=l626 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 21480 -15810 0 1 {name=l627 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 21360 -15880 0 0 {name=l628 sig_type=std_logic lab=BL[3]}
C {devices/lab_pin.sym} 21610 -15880 2 0 {name=l629 sig_type=std_logic lab=BLB[3]}
C {devices/lab_pin.sym} 21360 -15910 0 0 {name=l630 sig_type=std_logic lab=Din[3]}
C {devices/lab_pin.sym} 21360 -15930 0 0 {name=l631 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 22260 -15700 2 0 {name=l632 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 22200 -15700 0 0 {name=l633 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 22100 -15630 0 0 {name=l634 sig_type=std_logic lab=BL[4]}
C {devices/lab_pin.sym} 22340 -15630 2 0 {name=l635 sig_type=std_logic lab=BLB[4]}
C {devices/lab_pin.sym} 22210 -15980 2 0 {name=l636 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 22210 -15810 0 1 {name=l637 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 22090 -15880 0 0 {name=l638 sig_type=std_logic lab=BL[4]}
C {devices/lab_pin.sym} 22340 -15880 2 0 {name=l639 sig_type=std_logic lab=BLB[4]}
C {devices/lab_pin.sym} 22090 -15910 0 0 {name=l640 sig_type=std_logic lab=Din[4]}
C {devices/lab_pin.sym} 22090 -15930 0 0 {name=l641 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 22900 -15700 2 0 {name=l642 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 22840 -15700 0 0 {name=l643 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 22740 -15630 0 0 {name=l644 sig_type=std_logic lab=BL[5]}
C {devices/lab_pin.sym} 22980 -15630 2 0 {name=l645 sig_type=std_logic lab=BLB[5]}
C {devices/lab_pin.sym} 22840 -15970 2 0 {name=l646 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 22840 -15800 0 1 {name=l647 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 22720 -15870 0 0 {name=l648 sig_type=std_logic lab=BL[5]}
C {devices/lab_pin.sym} 22970 -15870 2 0 {name=l649 sig_type=std_logic lab=BLB[5]}
C {devices/lab_pin.sym} 22720 -15900 0 0 {name=l650 sig_type=std_logic lab=Din[5]}
C {devices/lab_pin.sym} 22720 -15920 0 0 {name=l651 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 23570 -15700 2 0 {name=l652 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 23510 -15700 0 0 {name=l653 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 23410 -15630 0 0 {name=l654 sig_type=std_logic lab=BL[6]}
C {devices/lab_pin.sym} 23650 -15630 2 0 {name=l655 sig_type=std_logic lab=BLB[6]}
C {devices/lab_pin.sym} 23510 -15960 2 0 {name=l656 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 23510 -15790 0 0 {name=l657 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 23390 -15860 0 0 {name=l658 sig_type=std_logic lab=BL[6]}
C {devices/lab_pin.sym} 23640 -15860 2 0 {name=l659 sig_type=std_logic lab=BLB[6]}
C {devices/lab_pin.sym} 23390 -15890 0 0 {name=l660 sig_type=std_logic lab=Din[6]}
C {devices/lab_pin.sym} 23390 -15910 0 0 {name=l661 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 24210 -15700 2 0 {name=l662 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 24150 -15700 0 0 {name=l663 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 24050 -15630 0 0 {name=l664 sig_type=std_logic lab=BL[7]}
C {devices/lab_pin.sym} 24290 -15630 2 0 {name=l665 sig_type=std_logic lab=BLB[7]}
C {devices/lab_pin.sym} 24180 -15940 2 0 {name=l666 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 24180 -15770 0 1 {name=l667 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 24060 -15840 0 0 {name=l668 sig_type=std_logic lab=BL[7]}
C {devices/lab_pin.sym} 24310 -15840 2 0 {name=l669 sig_type=std_logic lab=BLB[7]}
C {devices/lab_pin.sym} 24060 -15870 0 0 {name=l670 sig_type=std_logic lab=Din[7]}
C {devices/lab_pin.sym} 24060 -15890 0 0 {name=l671 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 24870 -15680 2 0 {name=l672 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 24810 -15680 0 0 {name=l673 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 24710 -15610 0 0 {name=l674 sig_type=std_logic lab=BL[8]}
C {devices/lab_pin.sym} 24950 -15610 2 0 {name=l675 sig_type=std_logic lab=BLB[8]}
C {devices/lab_pin.sym} 24840 -15940 2 0 {name=l676 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 24840 -15770 0 1 {name=l677 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 24720 -15840 0 0 {name=l678 sig_type=std_logic lab=BL[8]}
C {devices/lab_pin.sym} 24970 -15840 2 0 {name=l679 sig_type=std_logic lab=BLB[8]}
C {devices/lab_pin.sym} 24720 -15870 0 0 {name=l680 sig_type=std_logic lab=Din[8]}
C {devices/lab_pin.sym} 24720 -15890 0 0 {name=l681 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 25570 -15680 2 0 {name=l682 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 25510 -15680 0 0 {name=l683 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 25410 -15610 0 0 {name=l684 sig_type=std_logic lab=BL[9]}
C {devices/lab_pin.sym} 25650 -15610 2 0 {name=l685 sig_type=std_logic lab=BLB[9]}
C {devices/lab_pin.sym} 25510 -15940 2 0 {name=l686 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 25510 -15770 0 1 {name=l687 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 25390 -15840 0 0 {name=l688 sig_type=std_logic lab=BL[9]}
C {devices/lab_pin.sym} 25640 -15840 2 0 {name=l689 sig_type=std_logic lab=BLB[9]}
C {devices/lab_pin.sym} 25390 -15870 0 0 {name=l690 sig_type=std_logic lab=Din[9]}
C {devices/lab_pin.sym} 25390 -15890 0 0 {name=l691 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 26240 -15660 2 0 {name=l692 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 26180 -15660 0 0 {name=l693 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 26080 -15590 0 0 {name=l694 sig_type=std_logic lab=BL[10]}
C {devices/lab_pin.sym} 26320 -15590 2 0 {name=l695 sig_type=std_logic lab=BLB[10]}
C {devices/lab_pin.sym} 26190 -15940 2 0 {name=l696 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 26190 -15770 0 1 {name=l697 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 26070 -15840 0 0 {name=l698 sig_type=std_logic lab=BL[10]}
C {devices/lab_pin.sym} 26320 -15840 2 0 {name=l699 sig_type=std_logic lab=BLB[10]}
C {devices/lab_pin.sym} 26070 -15870 0 0 {name=l700 sig_type=std_logic lab=Din[10]}
C {devices/lab_pin.sym} 26070 -15890 0 0 {name=l701 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 26980 -15660 2 0 {name=l702 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 26920 -15660 0 0 {name=l703 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 26820 -15590 0 0 {name=l704 sig_type=std_logic lab=BL[11]}
C {devices/lab_pin.sym} 27060 -15590 2 0 {name=l705 sig_type=std_logic lab=BLB[11]}
C {devices/lab_pin.sym} 26920 -15940 2 0 {name=l706 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 26920 -15770 0 1 {name=l707 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 26800 -15840 0 0 {name=l708 sig_type=std_logic lab=BL[11]}
C {devices/lab_pin.sym} 27050 -15840 2 0 {name=l709 sig_type=std_logic lab=BLB[11]}
C {devices/lab_pin.sym} 26800 -15870 0 0 {name=l710 sig_type=std_logic lab=Din[11]}
C {devices/lab_pin.sym} 26800 -15890 0 0 {name=l711 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 27640 -15670 2 0 {name=l712 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 27580 -15670 0 0 {name=l713 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 27480 -15600 0 0 {name=l714 sig_type=std_logic lab=BL[12]}
C {devices/lab_pin.sym} 27720 -15600 2 0 {name=l715 sig_type=std_logic lab=BLB[12]}
C {devices/lab_pin.sym} 27580 -15950 2 0 {name=l716 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 27580 -15780 0 1 {name=l717 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 27460 -15850 0 0 {name=l718 sig_type=std_logic lab=BL[12]}
C {devices/lab_pin.sym} 27710 -15850 2 0 {name=l719 sig_type=std_logic lab=BLB[12]}
C {devices/lab_pin.sym} 27460 -15880 0 0 {name=l720 sig_type=std_logic lab=Din[12]}
C {devices/lab_pin.sym} 27460 -15900 0 0 {name=l721 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 28310 -15670 2 0 {name=l722 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 28250 -15670 0 0 {name=l723 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 28150 -15600 0 0 {name=l724 sig_type=std_logic lab=BL[13]}
C {devices/lab_pin.sym} 28390 -15600 2 0 {name=l725 sig_type=std_logic lab=BLB[13]}
C {devices/lab_pin.sym} 28250 -15950 2 0 {name=l726 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 28250 -15780 0 1 {name=l727 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 28130 -15850 0 0 {name=l728 sig_type=std_logic lab=BL[13]}
C {devices/lab_pin.sym} 28380 -15850 2 0 {name=l729 sig_type=std_logic lab=BLB[13]}
C {devices/lab_pin.sym} 28130 -15880 0 0 {name=l730 sig_type=std_logic lab=Din[13]}
C {devices/lab_pin.sym} 28130 -15900 0 0 {name=l731 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 29040 -15670 2 0 {name=l732 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 28980 -15670 0 0 {name=l733 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 28880 -15600 0 0 {name=l734 sig_type=std_logic lab=BL[14]}
C {devices/lab_pin.sym} 29120 -15600 2 0 {name=l735 sig_type=std_logic lab=BLB[14]}
C {devices/lab_pin.sym} 28980 -15950 2 0 {name=l736 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 28980 -15780 0 1 {name=l737 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 28860 -15850 0 0 {name=l738 sig_type=std_logic lab=BL[14]}
C {devices/lab_pin.sym} 29110 -15850 2 0 {name=l739 sig_type=std_logic lab=BLB[14]}
C {devices/lab_pin.sym} 28860 -15880 0 0 {name=l740 sig_type=std_logic lab=Din[14]}
C {devices/lab_pin.sym} 28860 -15900 0 0 {name=l741 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 29720 -15670 2 0 {name=l742 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 29660 -15670 0 0 {name=l743 sig_type=std_logic lab=PRE_SRAM}
C {devices/lab_pin.sym} 29560 -15600 0 0 {name=l744 sig_type=std_logic lab=BL[15]}
C {devices/lab_pin.sym} 29800 -15600 2 0 {name=l745 sig_type=std_logic lab=BLB[15]}
C {devices/lab_pin.sym} 29660 -15960 2 0 {name=l746 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 29660 -15790 0 1 {name=l747 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 29540 -15860 0 0 {name=l748 sig_type=std_logic lab=BL[15]}
C {devices/lab_pin.sym} 29790 -15860 2 0 {name=l749 sig_type=std_logic lab=BLB[15]}
C {devices/lab_pin.sym} 29540 -15890 0 0 {name=l750 sig_type=std_logic lab=Din[15]}
C {devices/lab_pin.sym} 29540 -15910 0 0 {name=l751 sig_type=std_logic lab=WE}
C {devices/lab_pin.sym} 19620 -14780 2 0 {name=l752 sig_type=std_logic lab=BL[0]}
C {devices/lab_pin.sym} 19570 -14770 1 0 {name=l753 sig_type=std_logic lab=BLB[0]}
C {devices/lab_pin.sym} 19520 -14770 0 0 {name=l754 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 19570 -14470 2 0 {name=l755 sig_type=std_logic lab=SA_OUT[0]}
C {devices/lab_pin.sym} 19440 -14630 0 0 {name=l756 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 20290 -14780 2 0 {name=l758 sig_type=std_logic lab=BL[1]}
C {devices/lab_pin.sym} 20240 -14780 1 0 {name=l759 sig_type=std_logic lab=BLB[1]}
C {devices/lab_pin.sym} 20190 -14770 0 0 {name=l760 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 20240 -14470 2 0 {name=l761 sig_type=std_logic lab=SA_OUT[1]}
C {devices/lab_pin.sym} 20110 -14630 0 0 {name=l762 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 20990 -14780 2 0 {name=l764 sig_type=std_logic lab=BL[2]}
C {devices/lab_pin.sym} 20940 -14770 1 0 {name=l765 sig_type=std_logic lab=BLB[2]}
C {devices/lab_pin.sym} 20890 -14770 0 0 {name=l766 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 20940 -14470 2 0 {name=l767 sig_type=std_logic lab=SA_OUT[2]}
C {devices/lab_pin.sym} 20810 -14630 0 0 {name=l768 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 21660 -14780 2 0 {name=l770 sig_type=std_logic lab=BL[3]}
C {devices/lab_pin.sym} 21610 -14780 1 0 {name=l771 sig_type=std_logic lab=BLB[3]}
C {devices/lab_pin.sym} 21560 -14770 0 0 {name=l772 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 21480 -14630 0 0 {name=l774 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 22320 -14790 2 0 {name=l776 sig_type=std_logic lab=BL[4]}
C {devices/lab_pin.sym} 22270 -14780 1 0 {name=l777 sig_type=std_logic lab=BLB[4]}
C {devices/lab_pin.sym} 22220 -14780 0 0 {name=l778 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 22270 -14480 2 0 {name=l779 sig_type=std_logic lab=SA_OUT[4]}
C {devices/lab_pin.sym} 22140 -14640 0 0 {name=l780 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 22990 -14790 2 0 {name=l782 sig_type=std_logic lab=BL[5]}
C {devices/lab_pin.sym} 22940 -14770 1 0 {name=l783 sig_type=std_logic lab=BLB[5]}
C {devices/lab_pin.sym} 22890 -14780 0 0 {name=l784 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 22940 -14480 2 0 {name=l785 sig_type=std_logic lab=SA_OUT[5]}
C {devices/lab_pin.sym} 22810 -14640 0 0 {name=l786 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 23690 -14790 2 0 {name=l788 sig_type=std_logic lab=BL[6]}
C {devices/lab_pin.sym} 23640 -14770 1 0 {name=l789 sig_type=std_logic lab=BLB[6]}
C {devices/lab_pin.sym} 23590 -14780 0 0 {name=l790 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 23640 -14480 2 0 {name=l791 sig_type=std_logic lab=SA_OUT[6]}
C {devices/lab_pin.sym} 23510 -14640 0 0 {name=l792 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 24360 -14790 2 0 {name=l794 sig_type=std_logic lab=BL[7]}
C {devices/lab_pin.sym} 24310 -14770 1 0 {name=l795 sig_type=std_logic lab=BLB[7]}
C {devices/lab_pin.sym} 24260 -14780 0 0 {name=l796 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 24310 -14480 2 0 {name=l797 sig_type=std_logic lab=SA_OUT[7]}
C {devices/lab_pin.sym} 24180 -14640 0 0 {name=l798 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 24940 -14780 2 0 {name=l800 sig_type=std_logic lab=BL[8]}
C {devices/lab_pin.sym} 24890 -14760 1 0 {name=l801 sig_type=std_logic lab=BLB[8]}
C {devices/lab_pin.sym} 24840 -14770 0 0 {name=l802 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 24890 -14470 2 0 {name=l803 sig_type=std_logic lab=SA_OUT[8]}
C {devices/lab_pin.sym} 24760 -14630 0 0 {name=l804 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 25610 -14780 2 0 {name=l806 sig_type=std_logic lab=BL[9]}
C {devices/lab_pin.sym} 25560 -14760 1 0 {name=l807 sig_type=std_logic lab=BLB[9]}
C {devices/lab_pin.sym} 25510 -14770 0 0 {name=l808 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 25560 -14470 2 0 {name=l809 sig_type=std_logic lab=SA_OUT[9]}
C {devices/lab_pin.sym} 25430 -14630 0 0 {name=l810 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 26310 -14780 2 0 {name=l812 sig_type=std_logic lab=BL[10]}
C {devices/lab_pin.sym} 26260 -14760 1 0 {name=l813 sig_type=std_logic lab=BLB[10]}
C {devices/lab_pin.sym} 26210 -14770 0 0 {name=l814 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 26260 -14470 2 0 {name=l815 sig_type=std_logic lab=SA_OUT[10]}
C {devices/lab_pin.sym} 26130 -14630 0 0 {name=l816 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 27090 -14760 2 0 {name=l818 sig_type=std_logic lab=BL[11]}
C {devices/lab_pin.sym} 27040 -14740 1 0 {name=l819 sig_type=std_logic lab=BLB[11]}
C {devices/lab_pin.sym} 26990 -14750 0 0 {name=l820 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 27040 -14450 2 0 {name=l821 sig_type=std_logic lab=SA_OUT[11]}
C {devices/lab_pin.sym} 26910 -14610 0 0 {name=l822 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 27710 -14760 2 0 {name=l824 sig_type=std_logic lab=BL[12]}
C {devices/lab_pin.sym} 27660 -14740 1 0 {name=l825 sig_type=std_logic lab=BLB[12]}
C {devices/lab_pin.sym} 27610 -14750 0 0 {name=l826 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 27660 -14450 2 0 {name=l827 sig_type=std_logic lab=SA_OUT[12]}
C {devices/lab_pin.sym} 27530 -14610 0 0 {name=l828 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 28390 -14750 2 0 {name=l830 sig_type=std_logic lab=BL[13]}
C {devices/lab_pin.sym} 28340 -14730 1 0 {name=l831 sig_type=std_logic lab=BLB[13]}
C {devices/lab_pin.sym} 28290 -14740 0 0 {name=l832 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 28340 -14440 2 0 {name=l833 sig_type=std_logic lab=SA_OUT[13]}
C {devices/lab_pin.sym} 28210 -14600 0 0 {name=l834 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 29110 -14750 2 0 {name=l836 sig_type=std_logic lab=BL[14]}
C {devices/lab_pin.sym} 29060 -14730 1 0 {name=l837 sig_type=std_logic lab=BLB[14]}
C {devices/lab_pin.sym} 29010 -14740 0 0 {name=l838 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 29060 -14440 2 0 {name=l839 sig_type=std_logic lab=SA_OUT[14]}
C {devices/lab_pin.sym} 28930 -14600 0 0 {name=l840 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 29770 -14750 2 0 {name=l842 sig_type=std_logic lab=BL[15]}
C {devices/lab_pin.sym} 29720 -14730 1 0 {name=l843 sig_type=std_logic lab=BLB[15]}
C {devices/lab_pin.sym} 29670 -14740 0 0 {name=l844 sig_type=std_logic lab=PRE_VLSA}
C {devices/lab_pin.sym} 29720 -14440 2 0 {name=l845 sig_type=std_logic lab=SA_OUT[15]}
C {devices/lab_pin.sym} 29590 -14600 0 0 {name=l846 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 19700 -14630 2 0 {name=l848 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20370 -14630 2 0 {name=l849 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 21070 -14630 2 0 {name=l850 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 21740 -14630 2 0 {name=l851 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 22390 -14640 2 0 {name=l852 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 23060 -14640 2 0 {name=l853 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 23760 -14640 2 0 {name=l854 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 29850 -14600 2 0 {name=l855 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 29190 -14600 2 0 {name=l856 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 28470 -14600 2 0 {name=l857 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 27790 -14610 2 0 {name=l858 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 27170 -14610 2 0 {name=l859 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 26390 -14630 2 0 {name=l860 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 25690 -14630 2 0 {name=l861 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 25020 -14630 2 0 {name=l862 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 18180 -15440 0 0 {name=p18 lab=Din[0:15]}
C {devices/ipin.sym} 18180 -15380 0 0 {name=p19 lab=WE}
C {devices/ipin.sym} 18180 -15320 0 0 {name=p20 lab=PRE_SRAM}
C {devices/ipin.sym} 18180 -15280 0 0 {name=p21 lab=PRE_VLSA}
C {Write_Driver.sym} 19600 -15900 0 0 {name=x66}
C {Precharge.sym} 18960 -15350 0 0 {name=x67}
C {10T_SRAM_bitcell_16x1_array.sym} 17730 -15100 0 0 {name=x68}
C {Sense_Amplifier.sym} 19230 -14610 0 0 {name=x69}
C {Write_Driver.sym} 20230 -15900 0 0 {name=x70}
C {Precharge.sym} 19600 -15350 0 0 {name=x71}
C {10T_SRAM_bitcell_16x1_array.sym} 18400 -15100 0 0 {name=x72}
C {Sense_Amplifier.sym} 19900 -14610 0 0 {name=x73}
C {Write_Driver.sym} 20910 -15900 0 0 {name=x74}
C {Precharge.sym} 20270 -15350 0 0 {name=x75}
C {10T_SRAM_bitcell_16x1_array.sym} 19070 -15100 0 0 {name=x76}
C {Sense_Amplifier.sym} 20600 -14610 0 0 {name=x77}
C {Write_Driver.sym} 21550 -15900 0 0 {name=x78}
C {Precharge.sym} 20910 -15350 0 0 {name=x79}
C {10T_SRAM_bitcell_16x1_array.sym} 19740 -15100 0 0 {name=x80}
C {Sense_Amplifier.sym} 21270 -14610 0 0 {name=x81}
C {Write_Driver.sym} 22280 -15900 0 0 {name=x82}
C {Precharge.sym} 21640 -15350 0 0 {name=x83}
C {10T_SRAM_bitcell_16x1_array.sym} 20420 -15110 0 0 {name=x84}
C {Sense_Amplifier.sym} 21930 -14620 0 0 {name=x85}
C {Write_Driver.sym} 22910 -15890 0 0 {name=x86}
C {Write_Driver.sym} 23580 -15880 0 0 {name=x87}
C {Write_Driver.sym} 24250 -15860 0 0 {name=x88}
C {Write_Driver.sym} 24910 -15860 0 0 {name=x89}
C {Write_Driver.sym} 25580 -15860 0 0 {name=x90}
C {Write_Driver.sym} 26260 -15860 0 0 {name=x91}
C {Write_Driver.sym} 26990 -15860 0 0 {name=x92}
C {Write_Driver.sym} 27650 -15870 0 0 {name=x93}
C {Write_Driver.sym} 28320 -15870 0 0 {name=x94}
C {Write_Driver.sym} 29050 -15870 0 0 {name=x95}
C {Write_Driver.sym} 29730 -15880 0 0 {name=x96}
C {Precharge.sym} 22280 -15350 0 0 {name=x97}
C {Precharge.sym} 22950 -15350 0 0 {name=x98}
C {Precharge.sym} 23590 -15350 0 0 {name=x99}
C {Precharge.sym} 24250 -15330 0 0 {name=x100}
C {Precharge.sym} 24950 -15330 0 0 {name=x101}
C {Precharge.sym} 25620 -15310 0 0 {name=x102}
C {Precharge.sym} 26360 -15310 0 0 {name=x103}
C {Precharge.sym} 27020 -15320 0 0 {name=x104}
C {Precharge.sym} 27690 -15320 0 0 {name=x105}
C {Precharge.sym} 28420 -15320 0 0 {name=x106}
C {Precharge.sym} 29100 -15320 0 0 {name=x107}
C {Sense_Amplifier.sym} 22600 -14620 0 0 {name=x108}
C {Sense_Amplifier.sym} 23300 -14620 0 0 {name=x109}
C {Sense_Amplifier.sym} 23970 -14620 0 0 {name=x110}
C {Sense_Amplifier.sym} 24550 -14610 0 0 {name=x111}
C {Sense_Amplifier.sym} 25220 -14610 0 0 {name=x112}
C {Sense_Amplifier.sym} 25920 -14610 0 0 {name=x113}
C {Sense_Amplifier.sym} 26700 -14590 0 0 {name=x114}
C {Sense_Amplifier.sym} 27320 -14590 0 0 {name=x115}
C {Sense_Amplifier.sym} 28000 -14580 0 0 {name=x116}
C {Sense_Amplifier.sym} 28720 -14580 0 0 {name=x117}
C {Sense_Amplifier.sym} 29380 -14580 0 0 {name=x118}
C {10T_SRAM_bitcell_16x1_array.sym} 21090 -15110 0 0 {name=x119}
C {10T_SRAM_bitcell_16x1_array.sym} 21760 -15110 0 0 {name=x120}
C {10T_SRAM_bitcell_16x1_array.sym} 22430 -15110 0 0 {name=x121}
C {10T_SRAM_bitcell_16x1_array.sym} 23050 -15100 0 0 {name=x122}
C {10T_SRAM_bitcell_16x1_array.sym} 23720 -15100 0 0 {name=x123}
C {10T_SRAM_bitcell_16x1_array.sym} 24390 -15100 0 0 {name=x124}
C {10T_SRAM_bitcell_16x1_array.sym} 25170 -15100 0 0 {name=x125}
C {10T_SRAM_bitcell_16x1_array.sym} 25810 -15110 0 0 {name=x126}
C {10T_SRAM_bitcell_16x1_array.sym} 26500 -15110 0 0 {name=x127}
C {10T_SRAM_bitcell_16x1_array.sym} 27220 -15120 0 0 {name=x128}
C {10T_SRAM_bitcell_16x1_array.sym} 27890 -15120 0 0 {name=x129}
C {devices/opin.sym} 18310 -15390 0 0 {name=p22 lab=SA_OUT[0:15]}
C {sky130_fd_pr/nfet_01v8.sym} 19590 -14210 0 1 {name=M12
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 19210 -14170 0 0 {name=M13[0:15]
L=0.15
W=0.42
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 19640 -14210 2 0 {name=l895 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 19550 -14210 2 1 {name=l896 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 19230 -14250 0 0 {name=l897 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 19140 -14170 0 0 {name=l898 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 19570 -14310 1 0 {name=l899 sig_type=std_logic lab=RBLX[0]}
C {sky130_fd_pr/nfet_01v8.sym} 20290 -14210 0 1 {name=M14
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 19910 -14170 0 0 {name=M15[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 20250 -14210 2 1 {name=l901 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 19930 -14250 0 0 {name=l902 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 19840 -14170 0 0 {name=l903 sig_type=std_logic lab=PRE}
C {sky130_fd_pr/nfet_01v8.sym} 20960 -14210 0 1 {name=M16
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 20580 -14170 0 0 {name=M17[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 20920 -14210 2 1 {name=l905 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 20600 -14250 0 0 {name=l906 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 21660 -14210 0 1 {name=M18
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 21280 -14170 0 0 {name=M19[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 21620 -14210 2 1 {name=l909 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 21300 -14250 0 0 {name=l910 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 22290 -14200 0 1 {name=M20
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 21910 -14160 0 0 {name=M21[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 22250 -14200 2 1 {name=l913 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 21930 -14240 0 0 {name=l914 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 22990 -14200 0 1 {name=M22
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 22610 -14160 0 0 {name=M23[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 22950 -14200 2 1 {name=l917 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 22630 -14240 0 0 {name=l918 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 23660 -14200 0 1 {name=M24
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 23280 -14160 0 0 {name=M25[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 23620 -14200 2 1 {name=l921 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 23300 -14240 0 0 {name=l922 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 24360 -14200 0 1 {name=M26
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 23980 -14160 0 0 {name=M27[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 24320 -14200 2 1 {name=l925 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 24000 -14240 0 0 {name=l926 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 24950 -14210 0 1 {name=M28
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 24570 -14170 0 0 {name=M29[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 24910 -14210 2 1 {name=l929 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 24590 -14250 0 0 {name=l930 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 25650 -14210 0 1 {name=M30
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 25270 -14170 0 0 {name=M31[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 25610 -14210 2 1 {name=l933 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 25290 -14250 0 0 {name=l934 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 26320 -14210 0 1 {name=M32
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 25940 -14170 0 0 {name=M33[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 26280 -14210 2 1 {name=l937 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 25960 -14250 0 0 {name=l938 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 27020 -14210 0 1 {name=M34
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 26640 -14170 0 0 {name=M35[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 26980 -14210 2 1 {name=l941 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 26660 -14250 0 0 {name=l942 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 27650 -14200 0 1 {name=M36
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 27270 -14160 0 0 {name=M37[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 27610 -14200 2 1 {name=l945 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 27290 -14240 0 0 {name=l946 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 28350 -14200 0 1 {name=M38
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 27970 -14160 0 0 {name=M39[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 28310 -14200 2 1 {name=l949 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 27990 -14240 0 0 {name=l950 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 29050 -14210 0 1 {name=M40
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 28670 -14170 0 0 {name=M41[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 29010 -14210 2 1 {name=l953 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 28690 -14250 0 0 {name=l954 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 29720 -14200 0 1 {name=M42
L=0.15
W=0.64
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 29340 -14160 0 0 {name=M43[0:15]
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 29680 -14200 2 1 {name=l957 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 29360 -14240 0 0 {name=l958 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20270 -14300 1 0 {name=l960 sig_type=std_logic lab=RBLX[1]}
C {devices/lab_pin.sym} 20940 -14310 1 0 {name=l961 sig_type=std_logic lab=RBLX[2]}
C {devices/lab_pin.sym} 29700 -14290 1 0 {name=l962 sig_type=std_logic lab=RBLX[15]}
C {devices/lab_pin.sym} 29030 -14300 1 0 {name=l963 sig_type=std_logic lab=RBLX[14]}
C {devices/lab_pin.sym} 28330 -14300 1 0 {name=l964 sig_type=std_logic lab=RBLX[13]}
C {devices/lab_pin.sym} 27630 -14300 1 0 {name=l965 sig_type=std_logic lab=RBLX[12]}
C {devices/lab_pin.sym} 27000 -14300 1 0 {name=l966 sig_type=std_logic lab=RBLX[11]}
C {devices/lab_pin.sym} 26300 -14300 1 0 {name=l967 sig_type=std_logic lab=RBLX[10]}
C {devices/lab_pin.sym} 25630 -14310 1 0 {name=l968 sig_type=std_logic lab=RBLX[9]}
C {devices/lab_pin.sym} 24930 -14310 1 0 {name=l969 sig_type=std_logic lab=RBLX[8]}
C {devices/lab_pin.sym} 24340 -14300 1 0 {name=l970 sig_type=std_logic lab=RBLX[7]}
C {devices/lab_pin.sym} 23640 -14290 1 0 {name=l971 sig_type=std_logic lab=RBLX[6]}
C {devices/lab_pin.sym} 22970 -14280 1 0 {name=l972 sig_type=std_logic lab=RBLX[5]}
C {devices/lab_pin.sym} 22270 -14280 1 0 {name=l973 sig_type=std_logic lab=RBLX[4]}
C {devices/lab_pin.sym} 21640 -14300 1 0 {name=l974 sig_type=std_logic lab=RBLX[3]}
C {devices/lab_pin.sym} 19560 -14980 3 0 {name=l863 sig_type=std_logic lab=RBLX[0]}
C {devices/lab_pin.sym} 20230 -14980 3 0 {name=l864 sig_type=std_logic lab=RBLX[1]}
C {devices/lab_pin.sym} 20900 -14980 3 0 {name=l865 sig_type=std_logic lab=RBLX[2]}
C {devices/lab_pin.sym} 21570 -14980 3 0 {name=l866 sig_type=std_logic lab=RBLX[3]}
C {devices/lab_pin.sym} 22250 -14990 3 0 {name=l867 sig_type=std_logic lab=RBLX[4]}
C {devices/lab_pin.sym} 22920 -14990 3 0 {name=l868 sig_type=std_logic lab=RBLX[5]}
C {devices/lab_pin.sym} 23590 -14990 3 0 {name=l869 sig_type=std_logic lab=RBLX[6]}
C {devices/lab_pin.sym} 24260 -14990 3 0 {name=l870 sig_type=std_logic lab=RBLX[7]}
C {devices/lab_pin.sym} 24880 -14980 3 0 {name=l871 sig_type=std_logic lab=RBLX[8]}
C {devices/lab_pin.sym} 25550 -14980 3 0 {name=l872 sig_type=std_logic lab=RBLX[9]}
C {devices/lab_pin.sym} 26220 -14980 3 0 {name=l873 sig_type=std_logic lab=RBLX[10]}
C {devices/lab_pin.sym} 27000 -14980 3 0 {name=l874 sig_type=std_logic lab=RBLX[11]}
C {devices/lab_pin.sym} 27640 -14990 3 0 {name=l875 sig_type=std_logic lab=RBLX[12]}
C {devices/lab_pin.sym} 28330 -14990 3 0 {name=l876 sig_type=std_logic lab=RBLX[13]}
C {devices/lab_pin.sym} 29050 -15000 3 0 {name=l877 sig_type=std_logic lab=RBLX[14]}
C {devices/lab_pin.sym} 29720 -15000 3 0 {name=l878 sig_type=std_logic lab=RBLX[15]}
C {devices/ipin.sym} 18170 -15170 0 0 {name=p1 lab=PRE_A}
C {devices/ipin.sym} 18160 -15050 0 0 {name=p2 lab=EN}
C {devices/lab_pin.sym} 19570 -13940 0 0 {name=l7 sig_type=std_logic lab=O0}
C {devices/lab_pin.sym} 20270 -13940 1 1 {name=l24 sig_type=std_logic lab=O1}
C {devices/lab_pin.sym} 20940 -13940 1 1 {name=l25 sig_type=std_logic lab=O2}
C {devices/lab_pin.sym} 21640 -13940 1 1 {name=l26 sig_type=std_logic lab=O3}
C {devices/lab_pin.sym} 22270 -13930 1 1 {name=l27 sig_type=std_logic lab=O4}
C {devices/lab_pin.sym} 22970 -13930 1 1 {name=l28 sig_type=std_logic lab=O5}
C {devices/lab_pin.sym} 24930 -13940 1 1 {name=l29 sig_type=std_logic lab=O8}
C {devices/lab_pin.sym} 24340 -13930 1 1 {name=l30 sig_type=std_logic lab=O7}
C {devices/lab_pin.sym} 23640 -13930 1 1 {name=l31 sig_type=std_logic lab=O6}
C {devices/lab_pin.sym} 25630 -13940 1 1 {name=l32 sig_type=std_logic lab=O9}
C {devices/lab_pin.sym} 26300 -13940 1 1 {name=l33 sig_type=std_logic lab=O10}
C {devices/lab_pin.sym} 27000 -13940 1 1 {name=l34 sig_type=std_logic lab=O11}
C {devices/lab_pin.sym} 27630 -13930 1 1 {name=l35 sig_type=std_logic lab=O12}
C {devices/lab_pin.sym} 28330 -13930 1 1 {name=l36 sig_type=std_logic lab=O13}
C {devices/lab_pin.sym} 29030 -13940 1 1 {name=l37 sig_type=std_logic lab=O14}
C {devices/lab_pin.sym} 29700 -13930 1 1 {name=l38 sig_type=std_logic lab=O15}
C {devices/ipin.sym} 18170 -15000 0 0 {name=p3 lab=Iref0}
C {devices/ipin.sym} 18170 -14960 0 0 {name=p4 lab=Iref1}
C {devices/ipin.sym} 18170 -14920 0 0 {name=p5 lab=Iref2}
C {devices/ipin.sym} 18170 -14880 0 0 {name=p6 lab=Iref3}
C {devices/ipin.sym} 18170 -15140 0 0 {name=p7 lab=SAEN}
C {devices/ipin.sym} 18170 -15090 0 0 {name=p8 lab=VCLP}
C {devices/ipin.sym} 18170 -15230 0 0 {name=p16 lab=PRE_CLSA}
C {devices/lab_pin.sym} 19450 -16160 0 0 {name=l114 sig_type=std_logic lab=BL[0]}
C {devices/lab_pin.sym} 19640 -16160 2 0 {name=l115 sig_type=std_logic lab=BLB[0]}
C {devices/lab_pin.sym} 19450 -16130 0 0 {name=l116 sig_type=std_logic lab=RBLX[0]}
C {devices/lab_pin.sym} 19640 -16130 2 0 {name=l117 sig_type=std_logic lab=RBLX[0]}
C {devices/lab_pin.sym} 19490 -16210 2 0 {name=l118 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 19580 -16090 2 0 {name=l119 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 19570 -16210 0 1 {name=l121 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 20080 -16160 0 0 {name=l122 sig_type=std_logic lab=BL[1]}
C {devices/lab_pin.sym} 20270 -16160 2 0 {name=l123 sig_type=std_logic lab=BLB[1]}
C {devices/lab_pin.sym} 20080 -16130 0 0 {name=l124 sig_type=std_logic lab=RBLX[1]}
C {devices/lab_pin.sym} 20270 -16130 2 0 {name=l125 sig_type=std_logic lab=RBLX[1]}
C {devices/lab_pin.sym} 20120 -16210 2 0 {name=l126 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20210 -16090 2 0 {name=l127 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 20760 -16160 0 0 {name=l130 sig_type=std_logic lab=BL[2]}
C {devices/lab_pin.sym} 20950 -16160 2 0 {name=l131 sig_type=std_logic lab=BLB[2]}
C {devices/lab_pin.sym} 20760 -16130 0 0 {name=l132 sig_type=std_logic lab=RBLX[2]}
C {devices/lab_pin.sym} 20950 -16130 2 0 {name=l133 sig_type=std_logic lab=RBLX[2]}
C {devices/lab_pin.sym} 20800 -16210 2 0 {name=l134 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20890 -16090 2 0 {name=l135 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 21390 -16170 0 0 {name=l137 sig_type=std_logic lab=BL[3]}
C {devices/lab_pin.sym} 21580 -16170 2 0 {name=l138 sig_type=std_logic lab=BLB[3]}
C {devices/lab_pin.sym} 21390 -16140 0 0 {name=l139 sig_type=std_logic lab=RBLX[3]}
C {devices/lab_pin.sym} 21580 -16140 2 0 {name=l140 sig_type=std_logic lab=RBLX[3]}
C {devices/lab_pin.sym} 21430 -16220 2 0 {name=l141 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 21520 -16100 2 0 {name=l142 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 22130 -16170 0 0 {name=l144 sig_type=std_logic lab=BL[4]}
C {devices/lab_pin.sym} 22320 -16170 2 0 {name=l145 sig_type=std_logic lab=BLB[4]}
C {devices/lab_pin.sym} 22130 -16140 0 0 {name=l146 sig_type=std_logic lab=RBLX[4]}
C {devices/lab_pin.sym} 22320 -16140 2 0 {name=l147 sig_type=std_logic lab=RBLX[4]}
C {devices/lab_pin.sym} 22170 -16220 2 0 {name=l148 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 22260 -16100 2 0 {name=l149 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 22750 -16170 0 0 {name=l151 sig_type=std_logic lab=BL[5]}
C {devices/lab_pin.sym} 22940 -16170 2 0 {name=l152 sig_type=std_logic lab=BLB[5]}
C {devices/lab_pin.sym} 22750 -16140 0 0 {name=l153 sig_type=std_logic lab=RBLX[5]}
C {devices/lab_pin.sym} 22940 -16140 2 0 {name=l154 sig_type=std_logic lab=RBLX[5]}
C {devices/lab_pin.sym} 22790 -16220 2 0 {name=l155 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 22880 -16100 2 0 {name=l156 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 23400 -16170 0 0 {name=l158 sig_type=std_logic lab=BL[6]}
C {devices/lab_pin.sym} 23590 -16170 2 0 {name=l159 sig_type=std_logic lab=BLB[6]}
C {devices/lab_pin.sym} 23400 -16140 0 0 {name=l160 sig_type=std_logic lab=RBLX[6]}
C {devices/lab_pin.sym} 23590 -16140 2 0 {name=l161 sig_type=std_logic lab=RBLX[6]}
C {devices/lab_pin.sym} 23440 -16220 2 0 {name=l162 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 23530 -16100 2 0 {name=l163 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 24090 -16170 0 0 {name=l165 sig_type=std_logic lab=BL[7]}
C {devices/lab_pin.sym} 24280 -16170 2 0 {name=l173 sig_type=std_logic lab=BLB[7]}
C {devices/lab_pin.sym} 24090 -16140 0 0 {name=l174 sig_type=std_logic lab=RBLX[7]}
C {devices/lab_pin.sym} 24280 -16140 2 0 {name=l175 sig_type=std_logic lab=RBLX[7]}
C {devices/lab_pin.sym} 24130 -16220 2 0 {name=l176 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 24220 -16100 2 0 {name=l177 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 24750 -16180 0 0 {name=l207 sig_type=std_logic lab=BL[8]}
C {devices/lab_pin.sym} 24940 -16180 2 0 {name=l208 sig_type=std_logic lab=BLB[8]}
C {devices/lab_pin.sym} 24750 -16150 0 0 {name=l209 sig_type=std_logic lab=RBLX[8]}
C {devices/lab_pin.sym} 24940 -16150 2 0 {name=l210 sig_type=std_logic lab=RBLX[8]}
C {devices/lab_pin.sym} 24790 -16230 2 0 {name=l211 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 24880 -16110 2 0 {name=l212 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 25430 -16180 0 0 {name=l216 sig_type=std_logic lab=BL[9]}
C {devices/lab_pin.sym} 25620 -16180 2 0 {name=l217 sig_type=std_logic lab=BLB[9]}
C {devices/lab_pin.sym} 25430 -16150 0 0 {name=l218 sig_type=std_logic lab=RBLX[9]}
C {devices/lab_pin.sym} 25620 -16150 2 0 {name=l219 sig_type=std_logic lab=RBLX[9]}
C {devices/lab_pin.sym} 25470 -16230 2 0 {name=l220 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 25560 -16110 2 0 {name=l221 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 26110 -16190 0 0 {name=l223 sig_type=std_logic lab=BL[10]}
C {devices/lab_pin.sym} 26300 -16190 2 0 {name=l224 sig_type=std_logic lab=BLB[10]}
C {devices/lab_pin.sym} 26110 -16160 0 0 {name=l225 sig_type=std_logic lab=RBLX[10]}
C {devices/lab_pin.sym} 26300 -16160 2 0 {name=l226 sig_type=std_logic lab=RBLX[10]}
C {devices/lab_pin.sym} 26150 -16240 2 0 {name=l227 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 26240 -16120 2 0 {name=l228 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 26820 -16180 0 0 {name=l236 sig_type=std_logic lab=BL[11]}
C {devices/lab_pin.sym} 27010 -16180 2 0 {name=l237 sig_type=std_logic lab=BLB[11]}
C {devices/lab_pin.sym} 26820 -16150 0 0 {name=l238 sig_type=std_logic lab=RBLX[11]}
C {devices/lab_pin.sym} 27010 -16150 2 0 {name=l241 sig_type=std_logic lab=RBLX[11]}
C {devices/lab_pin.sym} 26860 -16230 2 0 {name=l242 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 26950 -16110 2 0 {name=l243 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 28900 -16150 0 0 {name=l245 sig_type=std_logic lab=BL[14]}
C {devices/lab_pin.sym} 29090 -16150 2 0 {name=l274 sig_type=std_logic lab=BLB[14]}
C {devices/lab_pin.sym} 28900 -16120 0 0 {name=l275 sig_type=std_logic lab=RBLX[14]}
C {devices/lab_pin.sym} 29090 -16120 2 0 {name=l276 sig_type=std_logic lab=RBLX[14]}
C {devices/lab_pin.sym} 28940 -16200 2 0 {name=l277 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 29030 -16080 2 0 {name=l278 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 29570 -16150 0 0 {name=l280 sig_type=std_logic lab=BL[15]}
C {devices/lab_pin.sym} 29760 -16150 2 0 {name=l281 sig_type=std_logic lab=BLB[15]}
C {devices/lab_pin.sym} 29570 -16120 0 0 {name=l282 sig_type=std_logic lab=RBLX[15]}
C {devices/lab_pin.sym} 29760 -16120 2 0 {name=l283 sig_type=std_logic lab=RBLX[15]}
C {devices/lab_pin.sym} 29610 -16200 2 0 {name=l284 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 29700 -16080 2 0 {name=l285 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 27500 -16170 0 0 {name=l287 sig_type=std_logic lab=BL[12]}
C {devices/lab_pin.sym} 27690 -16170 2 0 {name=l288 sig_type=std_logic lab=BLB[12]}
C {devices/lab_pin.sym} 27500 -16140 0 0 {name=l289 sig_type=std_logic lab=RBLX[12]}
C {devices/lab_pin.sym} 27690 -16140 2 0 {name=l290 sig_type=std_logic lab=RBLX[12]}
C {devices/lab_pin.sym} 27540 -16220 2 0 {name=l291 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 27630 -16100 2 0 {name=l292 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 28160 -16150 0 0 {name=l294 sig_type=std_logic lab=BL[13]}
C {devices/lab_pin.sym} 28350 -16150 2 0 {name=l295 sig_type=std_logic lab=BLB[13]}
C {devices/lab_pin.sym} 28160 -16120 0 0 {name=l296 sig_type=std_logic lab=RBLX[13]}
C {devices/lab_pin.sym} 28350 -16120 2 0 {name=l297 sig_type=std_logic lab=RBLX[13]}
C {devices/lab_pin.sym} 28200 -16200 2 0 {name=l298 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 28290 -16080 2 0 {name=l299 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 20200 -16210 0 1 {name=l129 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 20880 -16210 0 1 {name=l136 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 21510 -16220 0 1 {name=l143 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 22250 -16220 0 1 {name=l150 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 22870 -16220 0 1 {name=l157 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 23520 -16220 0 1 {name=l164 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 24210 -16220 0 1 {name=l206 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 24870 -16230 0 1 {name=l215 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 25550 -16230 0 1 {name=l222 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 26230 -16240 0 1 {name=l235 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 26940 -16230 0 1 {name=l244 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 27620 -16220 0 1 {name=l293 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 28280 -16200 0 1 {name=l300 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 29020 -16200 0 1 {name=l279 sig_type=std_logic lab=WWLD[0:7]}
C {devices/lab_pin.sym} 29690 -16200 0 1 {name=l286 sig_type=std_logic lab=WWLD[0:7]}
C {Dummy_SRAM.sym} 19600 -16150 0 0 {name=x3}
C {Dummy_SRAM.sym} 20230 -16150 0 0 {name=x4}
C {Dummy_SRAM.sym} 20910 -16150 0 0 {name=x5}
C {Dummy_SRAM.sym} 21540 -16160 0 0 {name=x6}
C {Dummy_SRAM.sym} 22280 -16160 0 0 {name=x7}
C {Dummy_SRAM.sym} 22900 -16160 0 0 {name=x8}
C {Dummy_SRAM.sym} 23550 -16160 0 0 {name=x9}
C {Dummy_SRAM.sym} 24240 -16160 0 0 {name=x10}
C {Dummy_SRAM.sym} 24900 -16170 0 0 {name=x11}
C {Dummy_SRAM.sym} 25580 -16170 0 0 {name=x12}
C {Dummy_SRAM.sym} 26260 -16180 0 0 {name=x13}
C {Dummy_SRAM.sym} 26970 -16170 0 0 {name=x14}
C {Dummy_SRAM.sym} 27650 -16160 0 0 {name=x15}
C {Dummy_SRAM.sym} 28310 -16140 0 0 {name=x16}
C {Dummy_SRAM.sym} 29050 -16140 0 0 {name=x17}
C {Dummy_SRAM.sym} 29720 -16140 0 0 {name=x18}
C {devices/lab_pin.sym} 21610 -14470 2 0 {name=l317 sig_type=std_logic lab=SA_OUT[3]}
C {devices/opin.sym} 18320 -15270 0 0 {name=p17 lab=ADC0_OUT[0:3]}
C {devices/lab_pin.sym} 20880 -13810 1 0 {name=l23 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20900 -13810 3 1 {name=l113 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 20820 -13710 0 0 {name=l335 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 20830 -13650 0 0 {name=l336 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 20820 -13600 0 0 {name=l337 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 21580 -13810 1 0 {name=l354 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 21600 -13810 3 1 {name=l355 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 21520 -13710 0 0 {name=l356 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 21530 -13650 0 0 {name=l357 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 21520 -13600 0 0 {name=l358 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 22210 -13800 1 0 {name=l375 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 22230 -13800 3 1 {name=l376 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 22150 -13700 0 0 {name=l377 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 22160 -13640 0 0 {name=l378 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 22150 -13590 0 0 {name=l379 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 22910 -13800 1 0 {name=l396 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 22930 -13800 3 1 {name=l397 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 22850 -13700 0 0 {name=l398 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 22860 -13640 0 0 {name=l399 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 22850 -13590 0 0 {name=l400 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 23580 -13790 1 0 {name=l417 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 23600 -13790 3 1 {name=l418 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 23520 -13690 0 0 {name=l419 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 23530 -13630 0 0 {name=l420 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 23520 -13580 0 0 {name=l421 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 24280 -13800 1 0 {name=l438 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 24300 -13800 3 1 {name=l439 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 24220 -13700 0 0 {name=l440 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 24230 -13640 0 0 {name=l441 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 24220 -13590 0 0 {name=l442 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 24870 -13810 1 0 {name=l459 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 24890 -13810 3 1 {name=l460 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 24810 -13710 0 0 {name=l461 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 24820 -13650 0 0 {name=l462 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 24810 -13600 0 0 {name=l463 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 25570 -13810 1 0 {name=l495 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 25590 -13810 3 1 {name=l496 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 25510 -13710 0 0 {name=l773 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 25520 -13650 0 0 {name=l775 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 25510 -13600 0 0 {name=l879 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 26240 -13810 1 0 {name=l976 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 26260 -13810 3 1 {name=l977 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 26180 -13710 0 0 {name=l978 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 26190 -13650 0 0 {name=l979 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 26180 -13600 0 0 {name=l980 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 26940 -13810 1 0 {name=l997 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 26960 -13810 3 1 {name=l998 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 26880 -13710 0 0 {name=l999 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 26890 -13650 0 0 {name=l1000 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 26880 -13600 0 0 {name=l1001 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 27570 -13800 1 0 {name=l1018 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 27590 -13800 3 1 {name=l1019 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 27510 -13700 0 0 {name=l1020 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 27520 -13640 0 0 {name=l1021 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 27510 -13590 0 0 {name=l1022 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 28270 -13800 1 0 {name=l1039 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 28290 -13800 3 1 {name=l1040 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 28210 -13700 0 0 {name=l1041 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 28220 -13640 0 0 {name=l1042 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 28210 -13590 0 0 {name=l1043 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 28970 -13810 1 0 {name=l1060 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 28990 -13810 3 1 {name=l1061 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 28910 -13710 0 0 {name=l1062 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 28920 -13650 0 0 {name=l1063 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 28910 -13600 0 0 {name=l1064 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 29640 -13800 1 0 {name=l1081 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 29660 -13800 3 1 {name=l1082 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 29580 -13700 0 0 {name=l1083 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 29590 -13640 0 0 {name=l1084 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 29580 -13590 0 0 {name=l1085 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 19510 -13820 1 0 {name=l1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 19530 -13820 3 1 {name=l2 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 19450 -13720 0 0 {name=l3 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 19460 -13660 0 0 {name=l4 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 19450 -13610 0 0 {name=l5 sig_type=std_logic lab=PRE_CLSA}
C {devices/lab_pin.sym} 19640 -13480 3 0 {name=l15 sig_type=std_logic lab=ADC0_OUT[0]}
C {devices/lab_pin.sym} 20210 -13810 1 0 {name=l39 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20230 -13810 3 1 {name=l40 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 20150 -13710 0 0 {name=l41 sig_type=std_logic lab=SAEN}
C {devices/lab_pin.sym} 20160 -13650 0 0 {name=l42 sig_type=std_logic lab=VCLP}
C {devices/lab_pin.sym} 20150 -13600 0 0 {name=l43 sig_type=std_logic lab=PRE_CLSA}
C {ADC_CLSA_4.sym} 19630 -13700 0 0 {name=x1}
C {ADC_CLSA_4.sym} 20330 -13690 0 0 {name=x2}
C {ADC_CLSA_4.sym} 21000 -13690 0 0 {name=x19}
C {ADC_CLSA_4.sym} 21700 -13690 0 0 {name=x20}
C {ADC_CLSA_4.sym} 22330 -13680 0 0 {name=x21}
C {ADC_CLSA_4.sym} 23030 -13680 0 0 {name=x22}
C {ADC_CLSA_4.sym} 23700 -13670 0 0 {name=x23}
C {ADC_CLSA_4.sym} 24400 -13680 0 0 {name=x24}
C {ADC_CLSA_4.sym} 24990 -13690 0 0 {name=x25}
C {ADC_CLSA_4.sym} 25690 -13690 0 0 {name=x26}
C {ADC_CLSA_4.sym} 26360 -13690 0 0 {name=x27}
C {ADC_CLSA_4.sym} 27060 -13690 0 0 {name=x28}
C {ADC_CLSA_4.sym} 27690 -13680 0 0 {name=x29}
C {ADC_CLSA_4.sym} 28390 -13680 0 0 {name=x30}
C {ADC_CLSA_4.sym} 29090 -13690 0 0 {name=x31}
C {ADC_CLSA_4.sym} 29760 -13680 0 0 {name=x32}
C {devices/lab_pin.sym} 19610 -13830 1 0 {name=l1027 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 19640 -13830 1 0 {name=l1032 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 19670 -13830 1 0 {name=l1033 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 19710 -13830 1 0 {name=l1034 sig_type=std_logic lab=Iref3}
C {devices/ipin.sym} 18190 -15590 0 0 {name=p25 lab=WWLD[0:7]}
C {devices/opin.sym} 18320 -15220 0 0 {name=p12 lab=ADC1_OUT[0:3]}
C {devices/opin.sym} 18320 -15170 0 0 {name=p13 lab=ADC2_OUT[0:3]}
C {devices/opin.sym} 18320 -15120 0 0 {name=p23 lab=ADC3_OUT[0:3]}
C {devices/opin.sym} 18320 -15070 0 0 {name=p24 lab=ADC4_OUT[0:3]}
C {devices/opin.sym} 18320 -15020 0 0 {name=p26 lab=ADC5_OUT[0:3]}
C {devices/opin.sym} 18320 -14970 0 0 {name=p27 lab=ADC6_OUT[0:3]}
C {devices/opin.sym} 18320 -14920 0 0 {name=p28 lab=ADC7_OUT[0:3]}
C {devices/opin.sym} 18320 -14870 0 0 {name=p29 lab=ADC8_OUT[0:3]}
C {devices/opin.sym} 18320 -14820 0 0 {name=p30 lab=ADC9_OUT[0:3]}
C {devices/opin.sym} 18320 -14770 0 0 {name=p31 lab=ADC10_OUT[0:3]}
C {devices/opin.sym} 18320 -14720 0 0 {name=p32 lab=ADC11_OUT[0:3]}
C {devices/opin.sym} 18320 -14670 0 0 {name=p33 lab=ADC12_OUT[0:3]}
C {devices/opin.sym} 18320 -14620 0 0 {name=p34 lab=ADC13_OUT[0:3]}
C {devices/opin.sym} 18320 -14570 0 0 {name=p35 lab=ADC14_OUT[0:3]}
C {devices/opin.sym} 18320 -14520 0 0 {name=p36 lab=ADC15_OUT[0:3]}
C {devices/lab_pin.sym} 24440 -14640 2 0 {name=l6 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20310 -13820 1 0 {name=l8 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 20340 -13820 1 0 {name=l9 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 20370 -13820 1 0 {name=l10 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 20410 -13820 1 0 {name=l11 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 20980 -13820 1 0 {name=l16 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 21010 -13820 1 0 {name=l17 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 21040 -13820 1 0 {name=l18 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 21080 -13820 1 0 {name=l19 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 21680 -13820 1 0 {name=l20 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 21710 -13820 1 0 {name=l21 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 21740 -13820 1 0 {name=l22 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 21780 -13820 1 0 {name=l44 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 22310 -13810 1 0 {name=l45 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 22340 -13810 1 0 {name=l46 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 22370 -13810 1 0 {name=l47 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 22410 -13810 1 0 {name=l48 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 23010 -13810 1 0 {name=l49 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 23040 -13810 1 0 {name=l50 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 23070 -13810 1 0 {name=l51 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 23110 -13810 1 0 {name=l52 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 23680 -13800 1 0 {name=l53 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 23710 -13800 1 0 {name=l54 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 23740 -13800 1 0 {name=l55 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 23780 -13800 1 0 {name=l56 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 24380 -13810 1 0 {name=l57 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 24410 -13810 1 0 {name=l58 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 24440 -13810 1 0 {name=l59 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 24480 -13810 1 0 {name=l60 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 24970 -13820 1 0 {name=l61 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 25000 -13820 1 0 {name=l62 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 25030 -13820 1 0 {name=l63 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 25070 -13820 1 0 {name=l64 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 25670 -13820 1 0 {name=l65 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 25700 -13820 1 0 {name=l66 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 25730 -13820 1 0 {name=l67 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 25770 -13820 1 0 {name=l68 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 26340 -13820 1 0 {name=l69 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 26370 -13820 1 0 {name=l70 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 26400 -13820 1 0 {name=l71 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 26440 -13820 1 0 {name=l72 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 27040 -13820 1 0 {name=l73 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 27070 -13820 1 0 {name=l74 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 27100 -13820 1 0 {name=l75 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 27140 -13820 1 0 {name=l76 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 27670 -13810 1 0 {name=l77 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 27700 -13810 1 0 {name=l78 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 27730 -13810 1 0 {name=l79 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 27770 -13810 1 0 {name=l80 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 28370 -13810 1 0 {name=l81 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 28400 -13810 1 0 {name=l82 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 28430 -13810 1 0 {name=l83 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 28470 -13810 1 0 {name=l84 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 29070 -13820 1 0 {name=l85 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 29100 -13820 1 0 {name=l86 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 29130 -13820 1 0 {name=l87 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 29170 -13820 1 0 {name=l88 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 29740 -13810 1 0 {name=l89 sig_type=std_logic lab=Iref0}
C {devices/lab_pin.sym} 29770 -13810 1 0 {name=l90 sig_type=std_logic lab=Iref1}
C {devices/lab_pin.sym} 29800 -13810 1 0 {name=l91 sig_type=std_logic lab=Iref2}
C {devices/lab_pin.sym} 29840 -13810 1 0 {name=l92 sig_type=std_logic lab=Iref3}
C {devices/lab_pin.sym} 19600 -13470 3 0 {name=l13 sig_type=std_logic lab=ADC0_OUT[1]}
C {devices/lab_pin.sym} 19560 -13480 3 0 {name=l14 sig_type=std_logic lab=ADC0_OUT[2]}
C {devices/lab_pin.sym} 19520 -13480 3 0 {name=l93 sig_type=std_logic lab=ADC0_OUT[3]}
C {devices/lab_pin.sym} 20340 -13470 3 0 {name=l12 sig_type=std_logic lab=ADC1_OUT[0]}
C {devices/lab_pin.sym} 20300 -13460 3 0 {name=l94 sig_type=std_logic lab=ADC1_OUT[1]}
C {devices/lab_pin.sym} 20260 -13470 3 0 {name=l95 sig_type=std_logic lab=ADC1_OUT[2]}
C {devices/lab_pin.sym} 20220 -13470 3 0 {name=l96 sig_type=std_logic lab=ADC1_OUT[3]}
C {devices/lab_pin.sym} 21010 -13470 3 0 {name=l97 sig_type=std_logic lab=ADC2_OUT[0]}
C {devices/lab_pin.sym} 20970 -13460 3 0 {name=l98 sig_type=std_logic lab=ADC2_OUT[1]}
C {devices/lab_pin.sym} 20930 -13470 3 0 {name=l99 sig_type=std_logic lab=ADC2_OUT[2]}
C {devices/lab_pin.sym} 20890 -13470 3 0 {name=l100 sig_type=std_logic lab=ADC2_OUT[3]}
C {devices/lab_pin.sym} 21710 -13470 3 0 {name=l101 sig_type=std_logic lab=ADC3_OUT[0]}
C {devices/lab_pin.sym} 21670 -13460 3 0 {name=l102 sig_type=std_logic lab=ADC3_OUT[1]}
C {devices/lab_pin.sym} 21630 -13470 3 0 {name=l103 sig_type=std_logic lab=ADC3_OUT[2]}
C {devices/lab_pin.sym} 21590 -13470 3 0 {name=l104 sig_type=std_logic lab=ADC3_OUT[3]}
C {devices/lab_pin.sym} 22340 -13460 3 0 {name=l105 sig_type=std_logic lab=ADC4_OUT[0]}
C {devices/lab_pin.sym} 22300 -13450 3 0 {name=l106 sig_type=std_logic lab=ADC4_OUT[1]}
C {devices/lab_pin.sym} 22260 -13460 3 0 {name=l107 sig_type=std_logic lab=ADC4_OUT[2]}
C {devices/lab_pin.sym} 22220 -13460 3 0 {name=l108 sig_type=std_logic lab=ADC4_OUT[3]}
C {devices/lab_pin.sym} 23040 -13460 3 0 {name=l109 sig_type=std_logic lab=ADC5_OUT[0]}
C {devices/lab_pin.sym} 23000 -13450 3 0 {name=l110 sig_type=std_logic lab=ADC5_OUT[1]}
C {devices/lab_pin.sym} 22960 -13460 3 0 {name=l111 sig_type=std_logic lab=ADC5_OUT[2]}
C {devices/lab_pin.sym} 22920 -13460 3 0 {name=l112 sig_type=std_logic lab=ADC5_OUT[3]}
C {devices/lab_pin.sym} 23710 -13490 3 0 {name=l120 sig_type=std_logic lab=ADC6_OUT[0]}
C {devices/lab_pin.sym} 23670 -13480 3 0 {name=l128 sig_type=std_logic lab=ADC6_OUT[1]}
C {devices/lab_pin.sym} 23630 -13490 3 0 {name=l166 sig_type=std_logic lab=ADC6_OUT[2]}
C {devices/lab_pin.sym} 23590 -13490 3 0 {name=l167 sig_type=std_logic lab=ADC6_OUT[3]}
C {devices/lab_pin.sym} 24410 -13460 3 0 {name=l168 sig_type=std_logic lab=ADC7_OUT[0]}
C {devices/lab_pin.sym} 24370 -13450 3 0 {name=l169 sig_type=std_logic lab=ADC7_OUT[1]}
C {devices/lab_pin.sym} 24330 -13460 3 0 {name=l170 sig_type=std_logic lab=ADC7_OUT[2]}
C {devices/lab_pin.sym} 24290 -13460 3 0 {name=l171 sig_type=std_logic lab=ADC7_OUT[3]}
C {devices/lab_pin.sym} 25000 -13470 3 0 {name=l172 sig_type=std_logic lab=ADC8_OUT[0]}
C {devices/lab_pin.sym} 24960 -13460 3 0 {name=l178 sig_type=std_logic lab=ADC8_OUT[1]}
C {devices/lab_pin.sym} 24920 -13470 3 0 {name=l179 sig_type=std_logic lab=ADC8_OUT[2]}
C {devices/lab_pin.sym} 24880 -13470 3 0 {name=l180 sig_type=std_logic lab=ADC8_OUT[3]}
C {devices/lab_pin.sym} 25700 -13470 3 0 {name=l181 sig_type=std_logic lab=ADC9_OUT[0]}
C {devices/lab_pin.sym} 25660 -13460 3 0 {name=l182 sig_type=std_logic lab=ADC9_OUT[1]}
C {devices/lab_pin.sym} 25620 -13470 3 0 {name=l183 sig_type=std_logic lab=ADC9_OUT[2]}
C {devices/lab_pin.sym} 25580 -13470 3 0 {name=l184 sig_type=std_logic lab=ADC9_OUT[3]}
C {devices/lab_pin.sym} 26370 -13470 3 0 {name=l185 sig_type=std_logic lab=ADC10_OUT[0]}
C {devices/lab_pin.sym} 26330 -13460 3 0 {name=l186 sig_type=std_logic lab=ADC10_OUT[1]}
C {devices/lab_pin.sym} 26290 -13470 3 0 {name=l187 sig_type=std_logic lab=ADC10_OUT[2]}
C {devices/lab_pin.sym} 26250 -13470 3 0 {name=l188 sig_type=std_logic lab=ADC10_OUT[3]}
C {devices/lab_pin.sym} 27070 -13470 3 0 {name=l189 sig_type=std_logic lab=ADC11_OUT[0]}
C {devices/lab_pin.sym} 27030 -13460 3 0 {name=l190 sig_type=std_logic lab=ADC11_OUT[1]}
C {devices/lab_pin.sym} 26990 -13470 3 0 {name=l191 sig_type=std_logic lab=ADC11_OUT[2]}
C {devices/lab_pin.sym} 26950 -13470 3 0 {name=l192 sig_type=std_logic lab=ADC11_OUT[3]}
C {devices/lab_pin.sym} 27700 -13460 3 0 {name=l193 sig_type=std_logic lab=ADC12_OUT[0]}
C {devices/lab_pin.sym} 27660 -13450 3 0 {name=l194 sig_type=std_logic lab=ADC12_OUT[1]}
C {devices/lab_pin.sym} 27620 -13460 3 0 {name=l195 sig_type=std_logic lab=ADC12_OUT[2]}
C {devices/lab_pin.sym} 27580 -13460 3 0 {name=l196 sig_type=std_logic lab=ADC12_OUT[3]}
C {devices/lab_pin.sym} 28400 -13460 3 0 {name=l197 sig_type=std_logic lab=ADC13_OUT[0]}
C {devices/lab_pin.sym} 28360 -13450 3 0 {name=l198 sig_type=std_logic lab=ADC13_OUT[1]}
C {devices/lab_pin.sym} 28320 -13460 3 0 {name=l199 sig_type=std_logic lab=ADC13_OUT[2]}
C {devices/lab_pin.sym} 28280 -13460 3 0 {name=l200 sig_type=std_logic lab=ADC13_OUT[3]}
C {devices/lab_pin.sym} 29100 -13470 3 0 {name=l201 sig_type=std_logic lab=ADC14_OUT[0]}
C {devices/lab_pin.sym} 29060 -13460 3 0 {name=l202 sig_type=std_logic lab=ADC14_OUT[1]}
C {devices/lab_pin.sym} 29020 -13470 3 0 {name=l203 sig_type=std_logic lab=ADC14_OUT[2]}
C {devices/lab_pin.sym} 28980 -13470 3 0 {name=l204 sig_type=std_logic lab=ADC14_OUT[3]}
C {devices/lab_pin.sym} 29770 -13460 3 0 {name=l205 sig_type=std_logic lab=ADC15_OUT[0]}
C {devices/lab_pin.sym} 29730 -13450 3 0 {name=l213 sig_type=std_logic lab=ADC15_OUT[1]}
C {devices/lab_pin.sym} 29690 -13460 3 0 {name=l214 sig_type=std_logic lab=ADC15_OUT[2]}
C {devices/lab_pin.sym} 29650 -13460 3 0 {name=l229 sig_type=std_logic lab=ADC15_OUT[3]}
C {devices/lab_pin.sym} 20510 -14170 0 0 {name=l230 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 21210 -14170 0 0 {name=l231 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 21840 -14160 0 0 {name=l232 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 22540 -14160 0 0 {name=l233 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 23210 -14160 0 0 {name=l234 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 23910 -14160 0 0 {name=l301 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 24500 -14170 0 0 {name=l302 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 25200 -14170 0 0 {name=l303 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 25870 -14170 0 0 {name=l304 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 26570 -14170 0 0 {name=l305 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 27210 -14160 0 0 {name=l306 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 27900 -14160 0 0 {name=l307 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 28600 -14170 0 0 {name=l308 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 29270 -14160 0 0 {name=l309 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 20340 -14210 2 0 {name=l310 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 21000 -14210 2 0 {name=l311 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 21700 -14210 2 0 {name=l312 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 22340 -14200 2 0 {name=l313 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 23030 -14200 2 0 {name=l314 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 23700 -14200 2 0 {name=l315 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 24410 -14200 2 0 {name=l316 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 25000 -14210 2 0 {name=l318 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 25700 -14210 2 0 {name=l319 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 26370 -14210 2 0 {name=l320 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 27070 -14210 2 0 {name=l321 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 27700 -14200 2 0 {name=l322 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 28390 -14200 2 0 {name=l323 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 29100 -14210 2 0 {name=l324 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} 29770 -14200 2 0 {name=l325 sig_type=std_logic lab=EN}

v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 440 -530 0 0 {name=p1 lab=clk}
C {devices/ipin.sym} 440 -490 0 0 {name=p2 lab=reset_n
}
C {devices/ipin.sym} 440 -440 0 0 {name=p3 lab=wbs_we_i
}
C {devices/ipin.sym} 440 -400 0 0 {name=p4 lab=wishbone_buffer_data_in[31:0]
}
C {devices/ipin.sym} 440 -360 0 0 {name=p5 lab=VCLP
}
C {devices/ipin.sym} 440 -320 0 0 {name=p6 lab=EN
}
C {devices/ipin.sym} 440 -270 0 0 {name=p7 lab=Iref0
}
C {devices/ipin.sym} 440 -230 0 0 {name=p8 lab=Iref1
}
C {devices/ipin.sym} 440 -190 0 0 {name=p9 lab=Iref2
}
C {devices/ipin.sym} 440 -150 0 0 {name=p10 lab=Iref3
}
C {devices/ipin.sym} 430 -110 0 0 {name=p11 lab=wishbone_rw_addr[31:0]
}
C {devices/opin.sym} 540 -410 0 0 {name=p12 lab=wishbone_databus_out[31:0]}
C {devices/iopin.sym} 530 -500 0 0 {name=p17 lab=VDD}
C {devices/iopin.sym} 530 -460 0 0 {name=p18 lab=VSS}
C {devices/opin.sym} 540 -370 0 0 {name=p14 lab=halt}
